# Keil uVision project Blank.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blank +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\CustomLibs\src;.\CustomLibs\inc;.\CMSIS\MDR32Fx\CoreSupport\CM3;.\CMSIS\MDR32Fx\DeviceSupport\MDR1986VE9x\inc;.\CMSIS\MDR32Fx\DeviceSupport\MDR1986VE9x\startup\arm;.\SPL\MDR32Fx;.\SPL\MDR32Fx\inc;.\SPL\MDR32Fx\inc\USB_Library;.\SPL\MDR32Fx\inc\IRQ_Handler_Template;.\SPL\MDR32Fx\src;.\SPL\MDR32Fx\src\USB_Library;.\SPL\MDR32Fx\src\IRQ_Handler_Template;.\RTE;..\Blank
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c MDR32F9Qx_usb_handlers.h
  group CMSIS
    ./CMSIS/MDR32Fx/CoreSupport/CM3/: core_cm3.h core_cmFunc.h core_cmInstr.h
    ./CMSIS/MDR32Fx/DeviceSupport/MDR1986VE9x/inc/: MDR32Fx.h
    ./CMSIS/MDR32Fx/DeviceSupport/MDR1986VE9x/startup/arm/: startup_MDR32F9Qx.S system_MDR32F9Qx.c system_MDR32F9Qx.h
  group SPL
    ./SPL/MDR32Fx/: MDR32F9Qx_config.h
    ./SPL/MDR32Fx/inc/: MDR32F9Qx_adc.h MDR32F9Qx_arinc429r.h MDR32F9Qx_arinc429t.h MDR32F9Qx_audio.h MDR32F9Qx_bkp.h MDR32F9Qx_can.h MDR32F9Qx_comp.h MDR32F9Qx_dac.h MDR32F9Qx_dma.h MDR32F9Qx_dsp.h MDR32F9Qx_ebc.h MDR32F9Qx_eeprom.h MDR32F9Qx_eth.h MDR32F9Qx_i2c.h MDR32F9Qx_iwdg.h MDR32F9Qx_keypad.h MDR32F9Qx_led.h MDR32F9Qx_mil_std_1553.h MDR32F9Qx_port.h MDR32F9Qx_power.h MDR32F9Qx_rst_clk.h MDR32F9Qx_sdio.h MDR32F9Qx_ssp.h MDR32F9Qx_timer.h MDR32F9Qx_uart.h MDR32F9Qx_usb.h MDR32F9Qx_wwdg.h
    ./SPL/MDR32Fx/src/: MDR32F9Qx_adc.c MDR32F9Qx_arinc429r.c MDR32F9Qx_arinc429t.c MDR32F9Qx_audio.c MDR32F9Qx_bkp.c MDR32F9Qx_can.c MDR32F9Qx_comp.c MDR32F9Qx_dac.c MDR32F9Qx_dma.c MDR32F9Qx_dsp.c MDR32F9Qx_ebc.c MDR32F9Qx_eeprom.c MDR32F9Qx_eeprom_cache.S MDR32F9Qx_eth.c MDR32F9Qx_i2c.c MDR32F9Qx_iwdg.c MDR32F9Qx_keypad.c MDR32F9Qx_led.c MDR32F9Qx_mil_std_1553.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_sdio.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c MDR32F9Qx_wwdg.c
    ./SPL/MDR32Fx/inc/USB_Library/: MDR32F9Qx_usb_CDC.h MDR32F9Qx_usb_device.h MDR32F9Qx_usb_default_handlers.h
    ./SPL/MDR32Fx/src/USB_Library/: MDR32F9Qx_usb_CDC.c MDR32F9Qx_usb_device.c
  group src
    ./CustomLibs/src/: ili9341.c delay.c compress.c adc.c command_sys_flex.c dac.c gpio.c ili9341_interface.c ili9341gfx.c led.c ring_buffer.c spi.c sys_clk.c usb.c dma.c command_sys_strict.c
  group inc
    ./CustomLibs/inc/: defines.h ili9341.h delay.h compress.h adc.h command_sys_flex.h dac.h dma.h gpio.h ili9341_interface.h ili9341gfx.h led.h pins.h ring_buffer.h spi.h command_sys_strict.h
software components: CMSIS:CORE 5.5.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
