options:
  parameters:
    author: Tomsov Vsevolod
    generate_options: qt_gui
    id: PlotFromSerial
    output_language: python
    title: Serial Plot
  states: {}

blocks:
- name: DAC_frequency
  id: variable_qtgui_label
  parameters:
    label: DAC frequency
    type: int
    value: (int)(DAC_sample_rate /(500 -  frequency))
  states: {}
- name: DAC_sample_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: 500 - 2
    value: '0'
  states: {}
- name: generate_signal
  id: variable_qtgui_push_button
  parameters:
    label: Triangle
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import serial
      import serial.tools.list_ports
      import time

      import numpy as np
      from gnuradio import gr
      import pmt

      MAX_DAC_NUM = 500   # Максимальное количество чисел, которое может быть записано в const_signal
      MAX_DAC_VAL = 10.0  # Максимальное значение на выходе ЦАП
      CHUNK_SIZE = 10     # Максимальное количество чисел в одной команде
      USB_PACKET_SIZE = 256 # байт


      class ADIBlock(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Read data from serial port and forward it to output. 
          portNumber is number, you can see in the name of your 
          serial port in device manager, like COM16 or COM7 
          """

          adc_num = 1
          
          def __init__(self, portNumber=7, mode = 3): 
              """arguments to this function show up as parameters in GRC"""
              self.portNumber = portNumber  # Сохраняем номер порта
              # portName = 'COM' + str(portNumber)                  # Concatenate string and number
              
              gr.sync_block.__init__(
                  self,
                  name = 'Analog Digital Interface',   
                  # in_sig = [np.float32],                          # Входы
                  in_sig = [],                          # Входы
                  out_sig = [np.float32, np.float32]  # Выходы
              )

              # Регистрация именованных входных и выходных портов
              self.message_port_register_in(pmt.intern('set_const_signal'))
              self.set_msg_handler(pmt.intern('set_const_signal'), self.handle_msg)
              # self.message_port_register_out(pmt.intern('msg_out'))

               # Инициализация переменных для COM порта
              self.port = None
              self.port_name = None
              self.baudrate = 2000000  # Здесь захардкожен baudrate
              self.mode = mode
              self.remaining_data = bytearray()  # Буфер для оставшихся данных
              
          def open_port(self):
              """Открывает COM порт, если он существует и не занят."""
              baudrate = 2000000
              portName = 'COM' + str(self.portNumber)

              # Получаем список доступных COM портов
              available_ports = [port.device for port in serial.tools.list_ports.comports()]

              if portName not in available_ports:
                  print(f"Ошибка: Порт {portName} не найден.")
                  return
              
              try:
                  # Пытаемся открыть порт
                  self.port = serial.Serial(portName, baudrate, timeout=3.0)
                  # Если порт уже был открыт, закрываем его и открываем заново
                  if self.port.is_open:
                      self.port.close()
                      self.port.open()
                  else:
                      self.port.open()
                  print(f"Порт {portName} успешно открыт.")
              except serial.SerialException as e:
                  # Если не удалось открыть порт (например, он занят), выводим сообщение об ошибке
                  print(f"Ошибка при открытии порта {portName}: {e}")
                  self.port = None


          def set_mode(self, mode_setting):
              command = "mode " + str(mode_setting)  
              try:
                  self.port.write(command.encode('ascii'))
                  print(f"Отправлено: {command}")
                  time.sleep(0.01)
              except serial.SerialException as e:
                  print(f"Ошибка при отправке данных: {e}")


          def handle_msg(self, msg):
              """Обработка входных сообщений."""
              # Преобразование сообщения в список чисел с плавающей запятой
              numbers = pmt.to_python(msg)        # Преобразование в строку
              numbers = [float(x) for x in numbers.split()]
              print("AAAAAAAAAAAAAAAAAAAAAA")
              # print(numbers[30])

              # if not isinstance(numbers, list):
              #     print("Ошибка: Ожидался список чисел.")
              #     return

              if len(numbers) > MAX_DAC_NUM:
                  print(f"Ошибка: Слишком много чисел. Максимум {MAX_DAC_NUM}.")
                  return

              if any(val > MAX_DAC_VAL for val in numbers):
                  print(f"Ошибка: Значения не могут превышать {MAX_DAC_VAL}.")
                  return

              # Открытие порта, если еще не открыт
              if self.port is None:
                  self.open_port()

              if self.port is not None and self.port.is_open:
                  # Разделение данных на куски по 10 чисел и отправка
                  for i in range(0, len(numbers), CHUNK_SIZE):
                      chunk = numbers[i:i + CHUNK_SIZE]
                      command = "set " + " ".join(map(str, chunk))
                      if i + CHUNK_SIZE >= len(numbers):
                          command += " !"
                      
                      try:
                          self.port.write(command.encode('ascii'))
                          print(f"Отправлено: {command}")
                          time.sleep(0.01)
                      except serial.SerialException as e:
                          print(f"Ошибка при отправке данных: {e}")


                  
          def work(self, input_items, output_items):

              if self.port is None:
                  # Если порт не открыт, попытаться открыть его
                  self.open_port()
                  self.set_mode(self.mode)

              n = 0
              chunk_size = USB_PACKET_SIZE
              output_len = len(output_items[0])
              # data = bytearray(chunk_size)  # Создание массива байтов для чтения данных

                  
              while n < (output_len - chunk_size):
                  chunk_size = USB_PACKET_SIZE
              
                  # Объединяем остаточные данные из предыдущей итерации с новыми
                  if self.remaining_data:
                      chunk_size = len(self.remaining_data)
                      # print(chunk_size)
                      data = bytearray(chunk_size)  # Создание массива байтов для чтения данных
                      data = self.remaining_data
                      # print(data)
                      self.remaining_data = bytearray()  # Очищаем буфер
                  else:
                      data = bytearray(chunk_size)  # Создание массива байтов для чтения данных
                      self.port.readinto(data)  # Считывание данных непосредственно в массив байтов

                  if self.mode < 2:  # mode can be 0 or 1, оба включают только 1 канал АЦП
                      output_items[0][n:n + chunk_size] = data[:chunk_size]
                      n += chunk_size
                  else:
                      # TEST 8 bit
                      output_items[0][n:n + chunk_size // 2] = data[0::2]
                      output_items[1][n:n + chunk_size // 2] = data[1::2]
                      n += chunk_size // 2

              # Обработка оставшегося места в output_items
              if n < output_len:
                  self.port.readinto(data)  # Считываем данные в массив байтов
                  if self.mode < 2:  # mode can be 0 или 1, оба включают только 1 канал АЦП
                      bytes_to_copy = min(chunk_size, output_len - n)
                      output_items[0][n:n + bytes_to_copy] = data[:bytes_to_copy]
                      n += bytes_to_copy
                      self.remaining_data = data[bytes_to_copy:]  # Сохраняем оставшиеся данные
                  else:
                      i = 0
                      half_chunk_size = chunk_size // 2
                      while n < output_len and i < chunk_size:
                          output_items[0][n] = data[i] 
                          output_items[1][n] = data[i + 1]
                          n += 1
                          i += 2
                      self.remaining_data = data[i:]  # Сохраняем оставшиеся данные

              return len(output_items[0])  # Возвращаем количество обработанных элементов
    comment: |-
      mode = 0,    // 1ый канал АЦП, 1ый канал ЦАП 
       mode  = 1,    // 1ый канал АЦП, 2 канала ЦАП    
       mode  = 2,    // 2 канала АЦП, 1ый канала ЦАП  
       mode = 3,    // 2 канала АЦП, 2 канала ЦАП
    mode: '0'
    portNumber: '7'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class TriangleWaveGenerator(gr.sync_block):
          """
          Генератор треугольного сигнала.
          Принимает частоту и амплитуду как параметры через графический интерфейс.
          Передает сгенерированные значения в ADI блок.
          """

          def __init__(self, start_p = 0.0, end_p = 1.0, sample_rate = 250000, freq = 1000, enable = 0.0):
              gr.sync_block.__init__(
                  self,
                  name="Triangle Wave Generator",
                  in_sig=[],
                  out_sig=[np.float32]
              )

              # Инициализация переменных
              self.start_p = start_p
              self.end_p = end_p
              self.sample_rate = sample_rate
              self.freq = freq
              self.enable = enable 

              # Регистрация выходного порта для отправки данных
              self.message_port_register_out(pmt.intern('set_const_signal'))

              # Генерация и отправка треугольного сигнала при инициализации
              # signal_str = self.generate_triangle_wave(start_p, end_p, sample_rate, freq)

              # time.sleep(2.00)

              # # Отправка сгенерированных данных в ADI блок
              # self.message_port_pub(pmt.intern('set_const_signal'), pmt.intern(signal_str))

          def generate_triangle_wave(self, start, end, sample_rate, freq):
              """Генерация треугольного сигнала на основе параметров"""
              # 1. Округляем точки старта и конца
              start = round(start, 2)
              end = round(end, 2)
              
              # 2. Рассчитываем время для половины периода
              period = 1 / freq
              t_half = period / 2
              
              # 3. Вычисляем количество отсчетов
              num_samples = int(t_half * sample_rate)
              
              if num_samples < 1:
                  raise ValueError("Количество отсчетов должно быть больше или равно 1")
              
              # 5. Вычисляем дельту
              delta = (end - start) / num_samples
              
              # 6. Генерируем треугольный сигнал
              signal = []
              
              # Генерация увеличения
              for i in range(num_samples):
                  value = round(start + i * delta, 2)
                  signal.append(value)
              
              # Генерация уменьшения
              for i in range(num_samples):
                  value = round(end - i * delta, 2)
                  signal.append(value)
              
              # Преобразование в строку
              signal_str = " ".join(map(str, signal))
              print(f"Generated signal: {signal_str}")
              return signal_str

          done = 0
          def work(self, input_items, output_items):
              # Функция work выполняется пустой, так как сигнал генерируется только один раз
              n = 0
              while n < len(output_items[0]):
                  output_items[0][n] = self.enable
                  n += 1
              if self.enable == 1:
                      # print(f"Works")
              # # Генерация и отправка треугольного сигнала при инициализации
                  signal_str = self.generate_triangle_wave(self.start_p, self.end_p, self.sample_rate, self.freq)

                  time.sleep(2.00)

                  # Отправка сгенерированных данных в ADI блок
                  self.message_port_pub(pmt.intern('set_const_signal'), pmt.intern(signal_str))
              # done = 1
              # return 0
              return len(output_items[0])
    enable: generate_signal
    end_p: '3'
    freq: DAC_frequency
    sample_rate: DAC_sample_rate
    start_p: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    gui_hint: 0,0,1,1
    name: ''
    nconnections: '2'
    size: '5000'
    srate: '500000'
    type: float
    update_time: '0.01'
    ymax: '300'
  states: {}

connections:
- [epy_block_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [epy_block_0, '1', qtgui_time_sink_x_0_0_0, '1']
- [epy_block_1_0, '0', blocks_throttle2_0, '0']
- [epy_block_1_0, set_const_signal, epy_block_0, set_const_signal]

metadata:
  file_format: 1
  grc_version: 3.10.8.0
