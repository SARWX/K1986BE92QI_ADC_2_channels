options:
  parameters:
    author: ICV
    category: Custom
    generate_options: qt_gui
    id: qpsk_stage6
    output_language: python
    title: qpsk_stage6
  states: {}

blocks:
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: epy_block_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import serial
      import serial.tools.list_ports
      import time

      import numpy as np
      from gnuradio import gr
      import pmt

      MAX_DAC_NUM = 500   # Максимальное количество чисел, которое может быть записано в const_signal
      MAX_DAC_VAL = 10.0  # Максимальное значение на выходе ЦАП
      CHUNK_SIZE = 10     # Максимальное количество чисел в одной команде
      USB_PACKET_SIZE = 32 # байт

      class ADIBlock(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Read data from serial port and forward it to output. 
          portNumber is number, you can see in the name of your 
          serial port in device manager, like COM16 or COM7 
          DAC_freq and ADC_freq are specified for 1 channel
          """

          
          def __init__(self, portNumber=7, mode = 3, adc_freq = 250000, dac_freq = 500000): 
              """arguments to this function show up as parameters in GRC"""
              self.portNumber = portNumber  # Сохраняем номер порта       
              gr.sync_block.__init__(
                  self,
                  name = 'Analog Digital Interface',   
                  in_sig = [np.uint8, np.uint8],  # Входы
                  out_sig = [np.uint8, np.uint8]  # Выходы
              )

              # Регистрация именованных входных и выходных портов
              self.message_port_register_in(pmt.intern('set_const_signal'))
              self.message_port_register_in(pmt.intern('spi'))
              self.set_msg_handler(pmt.intern('set_const_signal'), self.handle_set_const_signal)
              self.set_msg_handler(pmt.intern('spi'), self.handle_spi)
              # self.message_port_register_out(pmt.intern('msg_out'))
              self.set_min_output_buffer(2**13)        # 512 - минимальный размер
              self.set_max_output_buffer(2**13)  # Установка максимального размера буфера
              self.set_output_multiple(2**13)     # Установка шага данных
              # Инициализация переменных для COM порта
              self.port = None
              self.port_name = None
              self.baudrate = 2000000  # Здесь захардкожен baudrate
              self.adc_freq = adc_freq  
              self.dac_freq = dac_freq
              self.mode = mode
              self.remaining_data = bytearray(USB_PACKET_SIZE + 1)  # Буфер для оставшихся данных     0ой байт - флаг (0 - в массиве нет полезных данных, 1 - надо читать)
              self.spi_len = 0
              

          def open_port(self):
              """Открывает COM порт, если он существует и не занят."""
              baudrate = 2000000
              portName = 'COM' + str(self.portNumber)
              # Получаем список доступных COM портов
              available_ports = [port.device for port in serial.tools.list_ports.comports()]
              if portName not in available_ports:
                  print(f"Ошибка: Порт {portName} не найден.")
                  return
              try:
                  # Пытаемся открыть порт
                  self.port = serial.Serial(portName, baudrate, timeout=3.0)
                  # Если порт уже был открыт, закрываем его и открываем заново
                  if self.port.is_open:
                      self.port.close()
                      self.port.open()
                  else:
                      self.port.open()
                  print(f"Порт {portName} успешно открыт.")
              except serial.SerialException as e:
                  # Если не удалось открыть порт (например, он занят), выводим сообщение об ошибке
                  print(f"Ошибка при открытии порта {portName}: {e}")
                  self.port = None


          def set_mode(self, mode_setting):
              if mode_setting < 4:
                  command = "mode " + str(mode_setting)  
              else:
                  command = "dac_mode"
              try:
                  self.port.write(command.encode('ascii'))
                  print(f"Отправлено: {command}")
                  time.sleep(0.01)
              except serial.SerialException as e:
                  print(f"Ошибка при отправке данных: {e}")

          def set_clock(self, dac_or_adc, adc_freq):
          # dac_or_adc = DAC      dac_or_adc = ADC
              command = "clock " + dac_or_adc + str(adc_freq)  
              try:
                  self.port.write(command.encode('ascii'))
                  print(f"Отправлено: {command}")
                  time.sleep(0.01)
              except serial.SerialException as e:
                  print(f"Ошибка при отправке данных: {e}")


          def handle_spi(self, msg):
              if self.spi_len == 0:
                  self.spi_len = pmt.to_python(msg)
                  print(self.spi_len)
                  print("SPI LEN IS SET")
                  return
                  
              spi_value = pmt.to_python(msg)        # Преобразование в int
              # Проверка
              print(spi_value)
              # Формирование ASCII строки
              # ascii_string = "spi1_send ".encode('ascii') + chr(self.spi_len) + ' ' + spi_value.to_bytes(6, 'big')
              ascii_string = (
                  b"spi1_send "  # Прямо задаем байтовую строку
                  + bytes([self.spi_len])  # Преобразуем spi_len в байты (один байт)
                  + b' '  # Пробел
                  + spi_value.to_bytes(self.spi_len, byteorder='big')  # Преобразуем spi_value в 6 байтов в big-endian
              )
              # Открытие порта, если еще не открыт
              if self.port is None:
                  self.open_port()
              if self.port is not None and self.port.is_open:
                  try:
                      self.port.write(ascii_string)
                      print(f"Отправлено spi1_send " + str(self.spi_len) + " " + str(spi_value))
                      time.sleep(0.01)
                  except serial.SerialException as e:
                      print(f"Ошибка при отправке данных: {e}")
                      
              print("SPI LEN IS RESET")
              self.spi_len = 0
              


          def handle_set_const_signal(self, msg):
              """Обработка входных сообщений."""
              # Преобразование сообщения в список чисел с плавающей запятой
              numbers = pmt.to_python(msg)        # Преобразование в строку
              numbers = [float(x) for x in numbers.split()]
              print("Обработка сообщения")
              if len(numbers) > MAX_DAC_NUM:
                  print(f"Ошибка: Слишком много чисел. Максимум {MAX_DAC_NUM}.")
                  return
              if any(val > MAX_DAC_VAL for val in numbers):
                  print(f"Ошибка: Значения не могут превышать {MAX_DAC_VAL}.")
                  return
              # Открытие порта, если еще не открыт
              if self.port is None:
                  self.open_port()
              if self.port is not None and self.port.is_open:
                  # Разделение данных на куски по 10 чисел и отправка
                  for i in range(0, len(numbers), CHUNK_SIZE):
                      chunk = numbers[i:i + CHUNK_SIZE]
                      command = "set " + " ".join(map(str, chunk))
                      if i + CHUNK_SIZE >= len(numbers):
                          command += " !"
                      try:
                          self.port.write(command.encode('ascii'))
                          print(f"Отправлено: {command}")
                          time.sleep(0.01)
                      except serial.SerialException as e:
                          print(f"Ошибка при отправке данных: {e}")

                  
          def work(self, input_items, output_items):

              if self.port is None:
                  # Если порт не открыт, попытаться открыть его
                  self.open_port()
                  if self.adc_freq > 0:
                      self.set_clock("ADC ", self.adc_freq)
                  if self.dac_freq > 0:
                      self.set_clock("DAC ", self.dac_freq)
                  self.set_mode(self.mode)

              # Случай обычной работы (Упор на АЦП)
              if self.mode < 4:
                  n = 0
                  chunk_size = USB_PACKET_SIZE
                  output_len = len(output_items[0])
                  data = bytearray(chunk_size)  # Создание массива байтов для чтения данных
                  n_increment = (USB_PACKET_SIZE if self.mode < 3 else (USB_PACKET_SIZE // 2))

                  while n < (output_len - n_increment):
                      chunk_size = USB_PACKET_SIZE
                  
                      # Объединяем остаточные данные из предыдущей итерации с новыми
                      if self.remaining_data[0] == 1:

                          # data = bytearray(chunk_size)  # Создание массива байтов для чтения данных
                          chunk_size = len(self.remaining_data) - 1
                          data = bytearray(chunk_size)
                          data = self.remaining_data[1:]       # Сохранить данные 
                          # print("DDDDDDDDDDDDDDDDD")
                          self.remaining_data = bytearray(USB_PACKET_SIZE + 1)  # Очищаем буфер
                      else:
                          data = bytearray(chunk_size)  # Создание массива байтов для чтения данных
                          self.port.readinto(data)  # Считывание данных непосредственно в массив байтов

                      if self.mode < 2:  # mode can be 0 or 1, оба включают только 1 канал АЦП
                          output_items[0][n:n + chunk_size] = data[:chunk_size]
                          n += chunk_size
                      else:
                          # TEST 8 bit
                          output_items[0][n:n + chunk_size // 2] = data[0::2]
                          output_items[1][n:n + chunk_size // 2] = data[1::2]
                          n += chunk_size // 2

                  # Обработка оставшегося места в output_items
                  if n < output_len:
                      self.port.readinto(data)  # Считываем данные в массив байтов
                      if self.mode < 2:  # mode can be 0 или 1, оба включают только 1 канал АЦП
                          # bytes_to_copy = min(chunk_size, output_len - n)
                          # output_items[0][n:n + bytes_to_copy] = data[:bytes_to_copy]
                          # n += bytes_to_copy
                          # print("EEEEEEEEEEEEEEEEEEEEEEEE")
                          # self.remaining_data = data[bytes_to_copy:]  # Сохраняем оставшиеся данные




                          i = 0
                          while n < output_len and i < chunk_size:
                              output_items[0][n] = data[i] 
                              n += 1
                              i += 1
                          # print("AAAAAAAAAAAAAA")
                          self.remaining_data = bytearray(USB_PACKET_SIZE - i + 1)
                          self.remaining_data[1:] = data[i:]  # Сохраняем оставшиеся данные
                          self.remaining_data[0] = (0 if (USB_PACKET_SIZE - i) == 0 else 1)  # Флаг запроса чтения
                      else:
                          i = 0
                          while n < output_len and i < chunk_size:
                              output_items[0][n] = data[i] 
                              output_items[1][n] = data[i + 1]
                              n += 1
                              i += 2
                          # print("AAAAAAAAAAAAAA")
                          self.remaining_data = bytearray(USB_PACKET_SIZE - i + 1)
                          self.remaining_data[1:] = data[i:]  # Сохраняем оставшиеся данные
                          self.remaining_data[0] = (0 if (USB_PACKET_SIZE - i) == 0 else 1)  # Флаг запроса чтения

                  return len(output_items[0])  # Возвращаем количество обработанных элементов

              # Случай, когда mode >= 4 (dac_mode) - упор на ЦАП, АЦП отключен
              else:
                  data = bytearray(USB_PACKET_SIZE )  # Создание массива байтов для чтения данных
                  n = 0
                  remaining_len = 0
                  input_len = min(len(input_items[0]), len(input_items[1]))  # Используем минимальную длину для избежания выхода за границы

                  # Если есть remaining_data, объединяем его с текущими данными
                  if self.remaining_data:
                      remaining_len = len(self.remaining_data)
                      # Увеличиваем размер буфера, добавляя длину remaining_data
                      data = self.remaining_data + data[:USB_PACKET_SIZE  - remaining_len]  # Ограничиваем data по размеру
                      # print("BBBBBBBBBBBBBBBBBB")
                      self.remaining_data = bytearray()  # Очищаем буфер после объединения

                  while n < input_len:
                      i = remaining_len  # Сбрасываем индекс для data
                      while i < (USB_PACKET_SIZE ) and n < input_len:  # Проверяем и n
                          value1 = int((input_items[0][n]) * 4000) & 0xFFF  # Приведение к целому числу и ограничение до 16 бит
                          data[i] = value1 & 0xFF  # Младший байт
                          data[i + 1] = (value1 >> 8) & 0xFF  # Старший байт
                          i += 2
                          value2 = int((input_items[1][n]) * 4000) & 0xFFF  # Приведение к целому числу и ограничение до 16 бит
                          data[i] = value2 & 0xFF  # Младший байт
                          data[i + 1] = (value2 >> 8) & 0xFF  # Старший байт
                          i += 2
                          n += 1
                      # Отправляем собранные данные в порт
                      self.port.write(data)  # Отправляем только заполненную часть
                      remaining_len = 0
                      data = bytearray(USB_PACKET_SIZE )
                  # Обработка оставшихся данных
                  if n < input_len:
                      # print("CCCCCCCCCCCCCCCC")
                      remaining_data = bytearray()
                      while n < input_len and i < USB_PACKET_SIZE :
                          value1 = int((input_items[0][n]) * 4000) & 0xFFF
                          remaining_data.append(value1 & 0xFF)
                          remaining_data.append((value1 >> 8) & 0xFF)
                          i += 2
                          value2 = int((input_items[1][n]) * 4000) & 0xFFF
                          remaining_data.append(value2 & 0xFF)
                          remaining_data.append((value2 >> 8) & 0xFF)
                          i += 2
                          n += 1
                      # Сохраняем остаточные данные для следующего вызова
                      # print("FFFFFFFFFFFFFFFFFF")
                      self.remaining_data = remaining_data

                  return len(input_items[0])
    adc_freq: '0'
    comment: |-
      mode = 0 	- 1ый канал АЦП, 1ый канал ЦАП 
      mode  = 1	- 1ый канал АЦП, 2 канала ЦАП    
      mode  = 2	- 2 канала АЦП, 1ый канала ЦАП  
      mode = 3	- 2 канала АЦП, 2 канала ЦАП
      mode >= 4	- dac_mode
    dac_freq: '0'
    mode: '3'
    portNumber: '10'
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import enum


      # class Scheduler(enum.Enum):
      #     first_channel = 0
      #     second_channel = 1
      #     deinit = 2

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Filter IQ QPSK',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32, np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              # WAIT = 10

              WAIT = 10 * 8 * 4
              packet_size_bytes = 10  # Размер пакета в байтах
              packet_size_bits = packet_size_bytes * 8  # 10 байт = 80 бит
              bit_size = 4  # Размер бита (для расчета шага при чтении)
              packet_size_mes = packet_size_bits * bit_size  # 10 байт = 80 бит
              # "Планировщик" распределяющий по каналам (кто раньше 0->1, тот первый канал) 
              # scheduler = Scheduler.first_channel
              scheduler = 0

              # 1 - Заполнить выходной массив нулями
              output_items[0].fill(0)
              output_items[1].fill(0)
              
              i = 0
              j = 0

              exact_num_of_mes_per_bit = 4.33
              count_mes_per_pack = 0
              prev_start = 0

              output_len = len(output_items[0])
              input_len = len(input_items[0])

              # print(input_len, output_len)
              test_mark = 0
              

              chan_0_start_condition = False
              chan_0_start_index = 0
              chan_1_start_condition = False
              chan_1_start_index = 0
              chan_num_0 = 0
              chan_num_1 = 1

              start_condition_found = False  # Флаг, найдено ли start_condition
              read_started = False  # Флаг, началось ли чтение
              bits_read = 0  # Счетчик прочитанных битов

              # Не надо читать буфер, если в него не может поместиться как миниум 1 полноценный пакет
              # Размер буфера почему-то постоянно меняется 
              if (input_len < WAIT + packet_size_mes):
                  return(output_len)

              while i < (input_len - 7):
                  if not start_condition_found:
                      # 1 - Либо одновременно, либо с шагом в 1 оба канала должны перейти в 1 
                      # 1 - Проверяем условие: оба канала последовательно перешли на 1
                      if input_items[0][i] > 0.4:
                          if chan_0_start_condition == False:
                              chan_0_start_index = (i + 2 + 4)
                              chan_num_0 = scheduler            # каким каналом назначен первый
                              scheduler += 1
                          chan_0_start_condition = True
                      if input_items[1][i] > 0.4:
                          if chan_1_start_condition == False:
                              chan_1_start_index = (i + 2 + 4)
                              chan_num_1 = scheduler            # каким каналом назначен второй
                              scheduler += 1
                          chan_1_start_condition = True

                      if (chan_0_start_condition and chan_1_start_condition):
                          if (abs(chan_0_start_index - chan_1_start_index) < 4):
                              start_condition_found = True
                              # print(i - test_mark)
                              read_started = True
                              bits_read = 0  # Сбрасываем счетчик прочитанных битов
                          else:
                              chan_0_start_condition = False
                              chan_1_start_condition = False
                              # scheduler = Scheduler.first_channel
                              scheduler = 0
                          # # Посчитаем точно сколько измерений приходится на 1 бит
                          # if prev_start != 0:
                          #     count_mes_per_pack = i - prev_start
                          #     exact_num_of_mes_per_bit = count_mes_per_pack / packet_size_bits
                          #     print(exact_num_of_mes_per_bit)
                          # prev_start = i

                      # if input_items[0][i] > 0.5 and input_items[1][i] > 0.5:
                      #     start_condition_found = True
                      #     read_started = True
                      #     bits_read = 0  # Сбрасываем счетчик прочитанных битов
                  else:
                      if read_started and (bits_read < packet_size_bits):
                          # 2 - Читаем биты с текущего индекса с шагом exact_num_of_mes_per_bit
                          if (i - chan_0_start_index) >= 0 and (i - chan_0_start_index) % exact_num_of_mes_per_bit < 1.0:
                              output_items[chan_num_0][j // 2] = (1 if input_items[0][i] > 0.5 else 0)
                              j += 1
                              bits_read += 1
                          if (i - chan_1_start_index) >= 0 and (i - chan_1_start_index) % exact_num_of_mes_per_bit < 1.0:
                              output_items[chan_num_1][j // 2] = (1 if input_items[1][i] > 0.5 else 0)
                              j += 1
                              bits_read += 1
                      else:
                          # Чтение завершено, сбрасываем флаг и ищем новое start_condition
                          start_condition_found = False
                          read_started = False
                          chan_0_start_condition = False
                          chan_1_start_condition = False
                          bits_read = 0
                          scheduler = 0
                          j += packet_size_bits * 4   # (packet_size_bits * 2)    - нули и полезная нагрузка
                                                                                  # (+ 1) - 0x3               - начало фрейма
                                                                                  # (- packet_size_bits)      - мы уже передали 1 пакет битов, надо их учесть
                          stop_trig = 0
                          # i += (WAIT / 2)
                          while (i < input_len and stop_trig < (WAIT / 2)):
                              if ((input_items[0][i] < 0.4) and (input_items[0][i] < 0.4)):
                                  stop_trig += 1
                              else:
                                  # print("STOP: ", stop_trig)
                                  stop_trig = 0
                              i += 1
                          # print("END: ", stop_trig)
                          test_mark = i

                  i += 1  # Шаг в любом случае

              # output_items[0][0] = 2
              # output_items[0][output_len - 1] = 3
              # print(output_len)
              # print(input_len)

              return output_len
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, modulation_type = 0, mode = 0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Extract information IQ',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32]
              )
              self.num_good_bytes = 0
              self.num_bad_bytes = 0
              self.modulation_type = modulation_type
              self.mode = mode            # Stream / Messenger
              self.message = ""
              self.test_complite = 0 
              self.test_start_time = 0
              self.test_end_time = 0

          def work(self, input_items, output_items):
              GOOD_BYTE = "<"
              res_msec = 0
              output_len = len(output_items[0])
              input_len = len(input_items[0])
              packet_size_bytes = 10  # Размер пакета в байтах
              packet_size_bits = packet_size_bytes * 8  # 10 байт = 80 бит
              i = 0
              j = 0

              while i < output_len - packet_size_bytes * 8:
                  # 1 - прочитать пакет:
                  packet_str = ""
                  readed_bytes = 0

                  while (readed_bytes < packet_size_bytes) and (i < (output_len - 8)):
                      byte = 0
                      # QPSK
                      if self.modulation_type == 0:
                          for n in range(0, 4):
                              byte <<= 2
                              byte += (1 if input_items[1][i] > 0.5  else 0)
                              byte += (1 if input_items[0][i] > 0.5  else 0) * 2
                              i += 1
                      # QAM16
                      if self.modulation_type == 1:
                          for n in range(2):
                              byte <<= 4
                              # Работа с input_items[1][i]
                              byte += (0 if input_items[1][i] < 0.2 else 
                                      1 if input_items[1][i] < 0.4 else 
                                      2 if input_items[1][i] < 0.8 else 3)

                              # Работа с input_items[0][i]
                              byte += ((0 if input_items[0][i] < 0.2 else 
                                      1 if input_items[0][i] < 0.4 else 
                                      2 if input_items[0][i] < 0.8 else 3) * 4)
                              # Увеличиваем индекс
                              i += 1

                      output_items[0][j] = byte
                      j += 1
                      byte = chr(byte)

                      # Messenger
                      if self.mode == 1:
                          if byte.isprintable():
                              try:
                                  print(byte, end='')
                              except UnicodeEncodeError:
                                  pass  # Игнорируем символ, если его нельзя вывести

                      # Stream

                      # Test
                      elif self.mode == 2:
                          # ЗАМЕР СКОРОСТИ И ОШИБКИ
                          if ord(byte) > 0:
                              if byte == GOOD_BYTE:
                                  self.num_good_bytes += 1
                              else:
                                  self.num_bad_bytes += 1
                              if self.test_start_time == 0:
                                  self.test_start_time = time.time()

                  if self.num_good_bytes > 100000 and self.test_complite == 0:
                      self.test_end_time = time.time()
                      print("\n")
                      print("Bitrate:\t\t\t\t", int(self.num_good_bytes / (self.test_end_time - self.test_start_time)), " Bytes/s")
                      print("BER (bit error ratio):\t", round((self.num_bad_bytes / (self.num_good_bytes + self.num_bad_bytes)) * 100, 2) , " %")
                      self.test_complite = 1

              return output_len
    comment: |-
      modulation_type = 0	- QPSK
      modulation_type = 1	- QAM16

      mode = 0 	- stream
      mode = 1 	- messenger
      mode = 2 	- test
    mode: '1'
    modulation_type: '0'
  states: {}
- name: epy_block_1_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import enum


      # class Scheduler(enum.Enum):
      #     first_channel = 0
      #     second_channel = 1
      #     deinit = 2

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, modulation_type = 0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Filter IQ',   # will show up in GRC
                  in_sig=[np.uint8, np.uint8],
                  out_sig=[np.float32, np.float32]
              )
              # self.set_min_output_buffer(2**13)        # 512 - минимальный размер
              # # self.set_max_output_buffer(2**9)  # Установка максимального размера буфера
              # self.set_output_multiple(2**13)     # Установка шага данных

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.modulation_type = modulation_type

          def work(self, input_items, output_items):
              # WAIT = 10

              cnt_start_cond = 0

              WAIT = 10 * 8 * 4
              packet_size_bytes = 10  # Размер пакета в байтах
              packet_size_bits = packet_size_bytes * 8  # 10 байт = 80 бит
              bit_size = 4  # Размер бита (для расчета шага при чтении)
              packet_size_mes = packet_size_bits * bit_size  # 10 байт = 80 бит
              # "Планировщик" распределяющий по каналам (кто раньше 0->1, тот первый канал) 
              # scheduler = Scheduler.first_channel
              scheduler = 0

              # 1 - Заполнить выходной массив нулями
              output_items[0].fill(0)
              output_items[1].fill(0)
              
              i = 0
              j = 0

              exact_num_of_mes_per_bit = 4.33
              count_mes_per_pack = 0
              prev_start = 0

              output_len = len(output_items[0])
              # print("output len = ", output_len)
              input_len = len(input_items[0])
              # print("input len = ", input_len)


              # print(input_len, output_len)
              test_mark = 0
              

              chan_0_start_condition = False
              chan_0_start_index = 0
              chan_1_start_condition = False
              chan_1_start_index = 0
              chan_num_0 = 0
              chan_num_1 = 1

              start_condition_found = False  # Флаг, найдено ли start_condition
              read_started = False  # Флаг, началось ли чтение
              bits_read = 0  # Счетчик прочитанных битов

              # Не надо читать буфер, если в него не может поместиться как миниум 1 полноценный пакет
              # Размер буфера почему-то постоянно меняется 
              # if (input_len < WAIT + packet_size_mes):
              #     return(output_len)

              # Для нормализации будем делить заносимые значения на амплитуду
              amplitude = max(input_items[0])
              # Амплитуда не должна быть меньше 0.8
              # if amplitude < 0.8:
              if amplitude < 5:
                  return(output_len)
                  # amplitude = 1.0
              threshold = amplitude * 0.4
              
              # print(input_len)
              while i < (input_len - 7):
                  if not start_condition_found:
                      # 1 - Либо одновременно, либо с шагом в 1 оба канала должны перейти в 1 
                      # 1 - Проверяем условие: оба канала последовательно перешли на 1
                      if input_items[0][i] > threshold:
                          if chan_0_start_condition == False:
                              chan_0_start_index = (i + 2 + 4)
                              chan_num_0 = scheduler            # каким каналом назначен первый
                              scheduler += 1
                          chan_0_start_condition = True
                      if input_items[1][i] > threshold:
                          if chan_1_start_condition == False:
                              chan_1_start_index = (i + 2 + 4)
                              chan_num_1 = scheduler            # каким каналом назначен второй
                              scheduler += 1
                          chan_1_start_condition = True

                      if (chan_0_start_condition and chan_1_start_condition):
                          if (abs(chan_0_start_index - chan_1_start_index) < 8):
                              start_condition_found = True
                              cnt_start_cond += 1
                              read_started = True
                              bits_read = 0  # Сбрасываем счетчик прочитанных битов
                          else:
                              chan_0_start_condition = False
                              chan_1_start_condition = False
                              scheduler = 0
                  else:
                      if read_started and (bits_read < packet_size_bits):
                          # 2 - Читаем биты с текущего индекса с шагом exact_num_of_mes_per_bit
                          if (i - chan_0_start_index) >= 0 and (i - chan_0_start_index) % exact_num_of_mes_per_bit < 1.0:
                              # output_items[chan_num_0][j // 2] = (1 if input_items[0][i] > 0.5 else 0)
                              output_items[chan_num_0][j // 2] = (input_items[0][i] / amplitude)
                              j += 1
                              bits_read += (self.modulation_type + 1)
                          if (i - chan_1_start_index) >= 0 and (i - chan_1_start_index) % exact_num_of_mes_per_bit < 1.0:
                              # output_items[chan_num_1][j // 2] = (1 if input_items[1][i] > 0.5 else 0)
                              output_items[chan_num_1][j // 2] = (input_items[1][i] / amplitude)
                              j += 1
                              bits_read += (self.modulation_type + 1)
                              # print(bits_read, i)
                      else:
                          # Чтение завершено, сбрасываем флаг и ищем новое start_condition
                          # print("ENDED! i = ", i)
                          start_condition_found = False
                          read_started = False
                          chan_0_start_condition = False
                          chan_1_start_condition = False
                          bits_read = 0
                          scheduler = 0
                          j += int(packet_size_bits * 4 / (self.modulation_type + 1))   # (packet_size_bits * 2)    - нули и полезная нагрузка
                                                                                  # (+ 1) - 0x3               - начало фрейма
                                                                                  # (- packet_size_bits)      - мы уже передали 1 пакет битов, надо их учесть
                          stop_trig = 0
                          # while (i < input_len and (stop_trig < ((WAIT / 2) / (self.modulation_type * 3 + 1)))):
                          while (i < input_len and (stop_trig < (WAIT / 2) / (self.modulation_type * 2 + 1))):
                          # while (i < input_len and (stop_trig < 4)):
                              if ((input_items[0][i] < threshold) and (input_items[0][i] < threshold)):
                                  stop_trig += 1
                                  # print("STOP_TRIG = ", stop_trig) 
                              else:
                                  # print("DELETED STOP_TRIG WAS EQUAL = ", stop_trig) 
                                  stop_trig = 0
                              i += 1
                          test_mark = i
                          # print(i)
                  i += 1  # Шаг в любом случае

              # print(cnt_start_cond)
              return output_len
    comment: |-
      modulation_type = 0	- QPSK
      modulation_type = 1	- QAM16
    modulation_type: '0'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,2,2
    size: '10000'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    xmax: '1.5'
    xmin: '-0.5'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,4
    size: 1024*4
    srate: '100000'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '256'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_2_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 1,2,2,2
    nconnections: '2'
    size: 1024*4
    srate: '100000'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymin: '0'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_null_source_0, '0', epy_block_0_0_0_0_0, '0']
- [blocks_null_source_0_0, '0', epy_block_0_0_0_0_0, '1']
- [epy_block_0_0_0_0_0, '0', epy_block_1_0_0_1, '0']
- [epy_block_0_0_0_0_0, '1', epy_block_1_0_0_1, '1']
- [epy_block_1_0_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [epy_block_1_0_0_1, '0', blocks_float_to_complex_0, '0']
- [epy_block_1_0_0_1, '0', epy_block_1_0_0_0, '0']
- [epy_block_1_0_0_1, '0', qtgui_time_sink_x_0_2_1, '0']
- [epy_block_1_0_0_1, '1', blocks_float_to_complex_0, '1']
- [epy_block_1_0_0_1, '1', epy_block_1_0_0_0, '1']
- [epy_block_1_0_0_1, '1', qtgui_time_sink_x_0_2_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
