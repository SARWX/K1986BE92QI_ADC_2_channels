options:
  parameters:
    author: Barry Duggan
    category: Custom
    generate_options: qt_gui
    id: qpsk_stage6
    output_language: python
    title: qpsk_stage6
  states: {}

blocks:
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '4'
  states: {}
- name: blocks_char_to_float_0_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '4'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (2, 2)
    type: byte
  states: {}
- name: blocks_stream_demux_0_0
  id: blocks_stream_demux
  parameters:
    lengths: (1, 1)
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport serial\nimport serial.tools.list_ports\nimport time\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nMAX_DAC_NUM = 500   # Максимальное количество чисел, которое может быть записано в const_signal\nMAX_DAC_VAL = 10.0  # Максимальное значение на выходе ЦАП\nCHUNK_SIZE = 10     # Максимальное количество чисел в одной команде\nUSB_PACKET_SIZE = 32 # байт\n# USB_PACKET_SIZE = 256 # байт              ДЛЯ dac mode\n\n\nclass ADIBlock(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"\n    Read data from serial port and forward it to output. \n    portNumber is number, you can see in the name of your \n    serial port in device manager, like COM16 or COM7 \n    \"\"\"\n\n    \n    def __init__(self, portNumber=7, mode = 3): \n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        self.portNumber = portNumber  # Сохраняем номер порта\n        # portName = 'COM' + str(portNumber)                  # Concatenate string and number\n        \n        gr.sync_block.__init__(\n            self,\n            name = 'Analog Digital Interface',   \n            in_sig = [np.float32, np.float32],                # Входы\n            out_sig = [np.float32, np.float32]  # Выходы\n        )\n\n        # Регистрация именованных входных и выходных портов\n        self.message_port_register_in(pmt.intern('set_const_signal'))\n        self.set_msg_handler(pmt.intern('set_const_signal'), self.handle_msg)\n        # self.message_port_register_out(pmt.intern('msg_out'))\n        self.set_min_output_buffer(2**13)        # 512 - минимальный размер\n        self.set_max_output_buffer(2**13)  # Установка максимального размера буфера\n        self.set_output_multiple(2**13)     # Установка шага данных\n\n         # Инициализация переменных для COM порта\n        self.port = None\n        self.port_name = None\n        self.baudrate = 2000000  # Здесь захардкожен baudrate\n        self.mode = mode\n        self.remaining_data = bytearray(USB_PACKET_SIZE + 1)  # Буфер для оставшихся данных     0ой байт - флаг (0 - в массиве нет полезных данных, 1 - надо читать)\n        \n    def open_port(self):\n        \"\"\"Открывает COM порт, если он существует и не занят.\"\"\"\n        baudrate = 2000000\n        portName = 'COM' + str(self.portNumber)\n\n        # Получаем список доступных COM портов\n        available_ports = [port.device for port in serial.tools.list_ports.comports()]\n\n        if portName not in available_ports:\n            print(f\"Ошибка: Порт {portName} не найден.\")\n            return\n        \n        try:\n            # Пытаемся открыть порт\n            self.port = serial.Serial(portName, baudrate, timeout=3.0)\n            # Если порт уже был открыт, закрываем его и открываем заново\n            if self.port.is_open:\n                self.port.close()\n                self.port.open()\n            else:\n                self.port.open()\n            print(f\"Порт {portName} успешно открыт.\")\n        except serial.SerialException as e:\n            # Если не удалось открыть порт (например, он занят), выводим сообщение об ошибке\n            print(f\"Ошибка при открытии порта {portName}: {e}\")\n            self.port = None\n\n\n    def set_mode(self, mode_setting):\n        if mode_setting < 4:\n            command = \"mode \" + str(mode_setting)  \n        else:\n            command = \"dac_mode\"\n        try:\n            self.port.write(command.encode('ascii'))\n            print(f\"Отправлено: {command}\")\n            time.sleep(0.01)\n        except serial.SerialException as e:\n            print(f\"Ошибка при отправке данных: {e}\")\n\n\n    def handle_msg(self, msg):\n        \"\"\"Обработка входных сообщений.\"\"\"\n        # Преобразование сообщения в список чисел с плавающей запятой\n        numbers = pmt.to_python(msg)        # Преобразование в строку\n        numbers = [float(x) for x in numbers.split()]\n        print(\"AAAAAAAAAAAAAAAAAAAAAA\")\n        # print(numbers[30])\n\n        # if not isinstance(numbers, list):\n        #     print(\"Ошибка: Ожидался список чисел.\")\n        #     return\n\n        if len(numbers) > MAX_DAC_NUM:\n            print(f\"Ошибка: Слишком много чисел. Максимум {MAX_DAC_NUM}.\")\n            return\n\n        if any(val > MAX_DAC_VAL for val in numbers):\n            print(f\"Ошибка: Значения не могут превышать {MAX_DAC_VAL}.\")\n            return\n\n        # Открытие порта, если еще не открыт\n        if self.port is None:\n            self.open_port()\n\n        if self.port is not None and self.port.is_open:\n            # Разделение данных на куски по 10 чисел и отправка\n            for i in range(0, len(numbers), CHUNK_SIZE):\n                chunk = numbers[i:i + CHUNK_SIZE]\n                command = \"set \" + \" \".join(map(str, chunk))\n                if i + CHUNK_SIZE >= len(numbers):\n                    command += \" !\"\n                \n                try:\n                    self.port.write(command.encode('ascii'))\n                    print(f\"Отправлено: {command}\")\n                    time.sleep(0.01)\n                except serial.SerialException as e:\n                    print(f\"Ошибка при отправке данных: {e}\")\n\n\n            \n    def work(self, input_items, output_items):\n\n        if self.port is None:\n            # Если порт не открыт, попытаться открыть его\n            self.open_port()\n            self.set_mode(self.mode)\n\n        # Случай обычной работы (Упор на АЦП)\n        if self.mode < 4:\n            n = 0\n            chunk_size = USB_PACKET_SIZE\n            output_len = len(output_items[0])\n            # print (output_len)\n            data = bytearray(chunk_size)  # Создание массива байтов для чтения данных\n            n_increment = (USB_PACKET_SIZE if self.mode < 3 else (USB_PACKET_SIZE // 2))\n\n                \n            while n < (output_len - n_increment):\n                chunk_size = USB_PACKET_SIZE\n            \n                # Объединяем остаточные данные из предыдущей итерации с новыми\n                if self.remaining_data[0] == 1:\n                    # data = bytearray(chunk_size)  # Создание массива байтов для чтения данных\n                    chunk_size = len(self.remaining_data) - 1\n                    data = bytearray(chunk_size)\n                    data = self.remaining_data[1:]       # Сохранить данные \n                    # print (data)\n                    # data[-1:] = b'\\x00'\n                    # print(len(self.remaining_data))\n                    # print(data)\n                    # print(\"YES\")\n                    # while True:\n                    #     pass\n                    self.remaining_data = bytearray(USB_PACKET_SIZE + 1)  # Очищаем буфер\n                else:\n                    data = bytearray(chunk_size)  # Создание массива байтов для чтения данных\n                    self.port.readinto(data)  # Считывание данных непосредственно в массив байтов\n\n                if self.mode < 2:  # mode can be 0 or 1, оба включают только 1 канал АЦП\n                    output_items[0][n:n + chunk_size] = data[:chunk_size]\n                    n += chunk_size\n                else:\n                    # TEST 8 bit\n                    output_items[0][n:n + chunk_size // 2] = data[0::2]\n                    output_items[1][n:n + chunk_size // 2] = data[1::2]\n                    # output_items[1][n] = b'\\x30'\n                    n += chunk_size // 2\n\n                    # TESST\n\n            # Обработка оставшегося места в output_items\n            if n < output_len:\n                self.port.readinto(data)  # Считываем данные в массив байтов\n                if self.mode < 2:  # mode can be 0 или 1, оба включают только 1 канал АЦП\n                    bytes_to_copy = min(chunk_size, output_len - n)\n                    output_items[0][n:n + bytes_to_copy] = data[:bytes_to_copy]\n                    n += bytes_to_copy\n                    self.remaining_data = data[bytes_to_copy:]  # Сохраняем оставшиеся данные\n                else:\n                    i = 0\n                    # print(n)\n                    while n < output_len and i < chunk_size:\n                        output_items[0][n] = data[i] \n                        output_items[1][n] = data[i + 1]\n                        n += 1\n                        i += 2\n                    # output_items[1][n-1] = 300\n                    self.remaining_data = bytearray(USB_PACKET_SIZE - i + 1)\n                    self.remaining_data[1:] = data[i:]  # Сохраняем оставшиеся данные\n                    self.remaining_data[0] = (0 if (USB_PACKET_SIZE - i) == 0 else 1)  # Флаг запроса чтения\n                    # print(n)\n                    # print(self.remaining_data)\n\n            return len(output_items[0])  # Возвращаем количество обработанных элементов\n\n\n\n\n                # Случай, когда mode >= 4 (dac_mode) - упор на ЦАП, АЦП отключен\n        # Случай, когда mode >= 4 (dac_mode) - упор на ЦАП, АЦП отключен\n        else:\n            data = bytearray(USB_PACKET_SIZE )  # Создание массива байтов для чтения данных\n            n = 0\n            remaining_len = 0\n            input_len = min(len(input_items[0]), len(input_items[1]))  # Используем минимальную длину для избежания выхода за границы\n            # print(input_len)\n\n            # Если есть remaining_data, объединяем его с текущими данными\n            if self.remaining_data:\n                remaining_len = len(self.remaining_data)\n                # Увеличиваем размер буфера, добавляя длину remaining_data\n                data = self.remaining_data + data[:USB_PACKET_SIZE  - remaining_len]  # Ограничиваем data по размеру\n                self.remaining_data = bytearray()  # Очищаем буфер после объединения\n\n            while n < input_len:\n                i = remaining_len  # Сбрасываем индекс для data\n\n                while i < (USB_PACKET_SIZE ) and n < input_len:  # Проверяем и n\n                    value1 = int((input_items[0][n]) * 4000) & 0xFFF  # Приведение к целому числу и ограничение до 16 бит\n                    data[i] = value1 & 0xFF  # Младший байт\n                    data[i + 1] = (value1 >> 8) & 0xFF  # Старший байт\n                    i += 2\n                    value2 = int((input_items[1][n]) * 4000) & 0xFFF  # Приведение к целому числу и ограничение до 16 бит\n                    data[i] = value2 & 0xFF  # Младший байт\n                    data[i + 1] = (value2 >> 8) & 0xFF  # Старший байт\n                    i += 2\n                    n += 1\n\n                # Отправляем собранные данные в порт\n                self.port.write(data)  # Отправляем только заполненную часть\n                remaining_len = 0\n                data = bytearray(USB_PACKET_SIZE )\n\n            # Обработка оставшихся данных\n            if n < input_len:\n                remaining_data = bytearray()\n\n                while n < input_len and i < USB_PACKET_SIZE :\n                    value1 = int((input_items[0][n]) * 4000) & 0xFFF\n                    remaining_data.append(value1 & 0xFF)\n                    remaining_data.append((value1 >> 8) & 0xFF)\n                    i += 2\n                    value2 = int((input_items[1][n]) * 4000) & 0xFFF\n                    remaining_data.append(value2 & 0xFF)\n                    remaining_data.append((value2 >> 8) & 0xFF)\n                    i += 2\n                    n += 1\n\n                # Сохраняем остаточные данные для следующего вызова\n                self.remaining_data = remaining_data\n\n            return len(input_items[0])\n\n"
    comment: |-
      mode = 0,    // 1ый канал АЦП, 1ый канал ЦАП 
      mode  = 1,    // 1ый канал АЦП, 2 канала ЦАП    
      mode  = 2,    // 2 канала АЦП, 1ый канала ЦАП  
      mode = 3,    // 2 канала АЦП, 2 канала ЦАП
      mode >= 4  // dac_mode
    mode: '20'
    portNumber: '7'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Messenger
      """

      #  epy_block_0.py
      #  created 10/17/2019

      import numpy as np
      from gnuradio import gr

      import pmt
      import math

      textboxValue = ""

      class my_sync_block(gr.sync_block):
          """
          reads input from a message port
          outputs packets of bytes
          """
          def __init__(self, modulation_type = 0):
              gr.sync_block.__init__(self,
                  name = "Messenger",
                  in_sig = None,
                  out_sig = [np.byte])
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('clear_input'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              # Публичные атрибуты
              self.modulation_type = modulation_type
              self.cleared = 0

              self.set_min_output_buffer(2**13)        # 512 - минимальный размер
              self.set_max_output_buffer(2**13)  # Установка максимального размера буфера
              self.set_output_multiple(2**13)     # Установка шага данных

          def handle_msg(self, msg):
              global textboxValue

              textboxValue = pmt.symbol_to_string (msg)
              # print (textboxValue)
          
          def work(self, input_items, output_items):
              global textboxValue

              PACKET_SIZE = 10
              WAIT = 10

              output_len = len(output_items[0])
              output_items[0].fill(0)

              # get length of string
              _len = len(textboxValue)
              # Вставить Start condition
              if self.modulation_type == 0:
                  start_condition = 3        # Это 2 единицы подряд (2 надо, чтобы на оба канала)
              else:
                  start_condition = 15        # Это по 2 единицы подряд на 2 канала

              pos_send = 0
              pos_src = 0


              if (_len > 0):
                  # terminate with LF
                  textboxValue += "\n" 
                  _len += 1

                  # Find good pos_send (not at the start)
                  pos_send = int(output_len - (_len * 2 + (_len // 10) + 10))

                  # divide by packets
                  for packet in range(math.ceil(_len / PACKET_SIZE)):
                      # print(packet)
                      # Start condition                                             
                      output_items[0][pos_send] = start_condition
                      pos_send += 1
                      # Information
                      for _ in range(PACKET_SIZE):
                          if pos_src < _len:
                              output_items[0][pos_send] = ord(textboxValue[pos_src])
                              pos_send += 1
                              pos_src += 1
                          else:
                              pos_send += 1
                      # Wait
                      # print(pos_send)
                      pos_send += WAIT
                  
                  # store elements in output array
                  # for x in range(_len):
                  #     output_items[0][x + 1] = ord(textboxValue[x])
                  textboxValue = ""
                  self.message_port_pub(pmt.intern('clear_input'), pmt.intern(''))
                  # print(output_len)
                  # return (pos_send)
                  self.cleared = 0
                  return (output_len)
              elif self.cleared == 1:
                  return (0)
              else:
                  self.cleared = 1
                  return(output_len)
    comment: |-
      modulation_type = 0	- QPSK
      modulation_type = 0	- QAM16
    modulation_type: '1'
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      # Constants
      WAIT = 10

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, mode = 0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Test string generator',   # will show up in GRC
                  in_sig=[],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.mode = mode  # QPSK = 0 или QAM16 = 1

          def work(self, input_items, output_items):
              i = 0
              default_level = "\0" * WAIT
              if self.mode == 0:
                  start_condition = chr(3)        # Это 2 единицы подряд (2 надо, чтобы на оба канала)
              else:
                  start_condition = chr(15)        # Это по 2 единицы подряд на 2 канала
              all_contelation_points = chr(27)

              # information = "Hello!!!!!"
              information = "<" * 10
              # information = all_contelation_points * 10

              messege = default_level + start_condition + information
              message_bytes = bytes(messege, 'ascii')
              mes_len = len(messege)
              output_len = len(output_items[0])
              while(i < (output_len - mes_len)):
                 # Переводим байты в целые числа и записываем в массив
                  output_items[0][i:i + mes_len] = np.frombuffer(message_bytes, dtype=np.byte)
                  i += mes_len
              return len(output_items[0])
    mode: '1'
  states: {state: disabled}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    key: '1'
    label: 'Messege to sent:'
    type: string
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    name: '"2"'
    size: '1024'
    srate: '10000000'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.010'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Witout"'
    nconnections: '2'
    size: 1024 * 10
    srate: '10000000'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.010'
  states: {}

connections:
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', epy_block_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0_1, '0', epy_block_0, '1']
- [blocks_char_to_float_0_0_0_1, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0_0_1, '0']
- [blocks_stream_demux_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_stream_demux_0, '1', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_stream_demux_0_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [blocks_stream_demux_0_0, '1', blocks_char_to_float_0_0_0_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_stream_demux_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_stream_demux_0_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, '1', blocks_null_sink_0_0, '0']
- [epy_block_1, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [epy_block_1, clear_input, qtgui_edit_box_msg_0, val]
- [epy_block_1_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [qtgui_edit_box_msg_0, msg, epy_block_1, msg_in]

metadata:
  file_format: 1
  grc_version: 3.10.8.0
