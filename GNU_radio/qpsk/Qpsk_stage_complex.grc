options:
  parameters:
    author: Barry Duggan
    category: Custom
    generate_options: qt_gui
    id: qpsk_stage6
    output_language: python
    title: qpsk_stage6
  states: {}

blocks:
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: 0,3,1,1
    gui_hint: 0,3,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '50'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.025'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-100'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-100'
    type: float
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.01'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.01'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport serial\nimport serial.tools.list_ports\nimport time\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nMAX_DAC_NUM = 500   # Максимальное количество чисел, которое может быть записано в const_signal\nMAX_DAC_VAL = 10.0  # Максимальное значение на выходе ЦАП\nCHUNK_SIZE = 10     # Максимальное количество чисел в одной команде\nUSB_PACKET_SIZE = 32 # байт\n# USB_PACKET_SIZE = 256 # байт              ДЛЯ dac mode\n\n\nclass ADIBlock(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"\n    Read data from serial port and forward it to output. \n    portNumber is number, you can see in the name of your \n    serial port in device manager, like COM16 or COM7 \n    \"\"\"\n\n    \n    def __init__(self, portNumber=7, mode = 3): \n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        self.portNumber = portNumber  # Сохраняем номер порта\n        # portName = 'COM' + str(portNumber)                  # Concatenate string and number\n        \n        gr.sync_block.__init__(\n            self,\n            name = 'Analog Digital Interface',   \n            in_sig = [np.float32, np.float32],                # Входы\n            out_sig = [np.float32, np.float32]  # Выходы\n        )\n\n        # Регистрация именованных входных и выходных портов\n        self.message_port_register_in(pmt.intern('set_const_signal'))\n        self.set_msg_handler(pmt.intern('set_const_signal'), self.handle_msg)\n        # self.message_port_register_out(pmt.intern('msg_out'))\n\n         # Инициализация переменных для COM порта\n        self.port = None\n        self.port_name = None\n        self.baudrate = 2000000  # Здесь захардкожен baudrate\n        self.mode = mode\n        self.remaining_data = bytearray(USB_PACKET_SIZE + 1)  # Буфер для оставшихся данных     0ой байт - флаг (0 - в массиве нет полезных данных, 1 - надо читать)\n        \n    def open_port(self):\n        \"\"\"Открывает COM порт, если он существует и не занят.\"\"\"\n        baudrate = 2000000\n        portName = 'COM' + str(self.portNumber)\n\n        # Получаем список доступных COM портов\n        available_ports = [port.device for port in serial.tools.list_ports.comports()]\n\n        if portName not in available_ports:\n            print(f\"Ошибка: Порт {portName} не найден.\")\n            return\n        \n        try:\n            # Пытаемся открыть порт\n            self.port = serial.Serial(portName, baudrate, timeout=3.0)\n            # Если порт уже был открыт, закрываем его и открываем заново\n            if self.port.is_open:\n                self.port.close()\n                self.port.open()\n            else:\n                self.port.open()\n            print(f\"Порт {portName} успешно открыт.\")\n        except serial.SerialException as e:\n            # Если не удалось открыть порт (например, он занят), выводим сообщение об ошибке\n            print(f\"Ошибка при открытии порта {portName}: {e}\")\n            self.port = None\n\n\n    def set_mode(self, mode_setting):\n        if mode_setting < 4:\n            command = \"mode \" + str(mode_setting)  \n        else:\n            command = \"dac_mode\"\n        try:\n            self.port.write(command.encode('ascii'))\n            print(f\"Отправлено: {command}\")\n            time.sleep(0.01)\n        except serial.SerialException as e:\n            print(f\"Ошибка при отправке данных: {e}\")\n\n\n    def handle_msg(self, msg):\n        \"\"\"Обработка входных сообщений.\"\"\"\n        # Преобразование сообщения в список чисел с плавающей запятой\n        numbers = pmt.to_python(msg)        # Преобразование в строку\n        numbers = [float(x) for x in numbers.split()]\n        print(\"AAAAAAAAAAAAAAAAAAAAAA\")\n        # print(numbers[30])\n\n        # if not isinstance(numbers, list):\n        #     print(\"Ошибка: Ожидался список чисел.\")\n        #     return\n\n        if len(numbers) > MAX_DAC_NUM:\n            print(f\"Ошибка: Слишком много чисел. Максимум {MAX_DAC_NUM}.\")\n            return\n\n        if any(val > MAX_DAC_VAL for val in numbers):\n            print(f\"Ошибка: Значения не могут превышать {MAX_DAC_VAL}.\")\n            return\n\n        # Открытие порта, если еще не открыт\n        if self.port is None:\n            self.open_port()\n\n        if self.port is not None and self.port.is_open:\n            # Разделение данных на куски по 10 чисел и отправка\n            for i in range(0, len(numbers), CHUNK_SIZE):\n                chunk = numbers[i:i + CHUNK_SIZE]\n                command = \"set \" + \" \".join(map(str, chunk))\n                if i + CHUNK_SIZE >= len(numbers):\n                    command += \" !\"\n                \n                try:\n                    self.port.write(command.encode('ascii'))\n                    print(f\"Отправлено: {command}\")\n                    time.sleep(0.01)\n                except serial.SerialException as e:\n                    print(f\"Ошибка при отправке данных: {e}\")\n\n\n            \n    def work(self, input_items, output_items):\n\n        if self.port is None:\n            # Если порт не открыт, попытаться открыть его\n            self.open_port()\n            self.set_mode(self.mode)\n\n        # Случай обычной работы (Упор на АЦП)\n        if self.mode < 4:\n            n = 0\n            chunk_size = USB_PACKET_SIZE\n            output_len = len(output_items[0])\n            # print (output_len)\n            data = bytearray(chunk_size)  # Создание массива байтов для чтения данных\n            n_increment = (USB_PACKET_SIZE if self.mode < 3 else (USB_PACKET_SIZE // 2))\n\n                \n            while n < (output_len - n_increment):\n                chunk_size = USB_PACKET_SIZE\n            \n                # Объединяем остаточные данные из предыдущей итерации с новыми\n                if self.remaining_data[0] == 1:\n                    # data = bytearray(chunk_size)  # Создание массива байтов для чтения данных\n                    chunk_size = len(self.remaining_data) - 1\n                    data = bytearray(chunk_size)\n                    data = self.remaining_data[1:]       # Сохранить данные \n                    # print (data)\n                    # data[-1:] = b'\\x00'\n                    # print(len(self.remaining_data))\n                    # print(data)\n                    # print(\"YES\")\n                    # while True:\n                    #     pass\n                    self.remaining_data = bytearray(USB_PACKET_SIZE + 1)  # Очищаем буфер\n                else:\n                    data = bytearray(chunk_size)  # Создание массива байтов для чтения данных\n                    self.port.readinto(data)  # Считывание данных непосредственно в массив байтов\n\n                if self.mode < 2:  # mode can be 0 or 1, оба включают только 1 канал АЦП\n                    output_items[0][n:n + chunk_size] = data[:chunk_size]\n                    n += chunk_size\n                else:\n                    # TEST 8 bit\n                    output_items[0][n:n + chunk_size // 2] = data[0::2]\n                    output_items[1][n:n + chunk_size // 2] = data[1::2]\n                    # output_items[1][n] = b'\\x30'\n                    n += chunk_size // 2\n\n                    # TESST\n\n            # Обработка оставшегося места в output_items\n            if n < output_len:\n                self.port.readinto(data)  # Считываем данные в массив байтов\n                if self.mode < 2:  # mode can be 0 или 1, оба включают только 1 канал АЦП\n                    bytes_to_copy = min(chunk_size, output_len - n)\n                    output_items[0][n:n + bytes_to_copy] = data[:bytes_to_copy]\n                    n += bytes_to_copy\n                    self.remaining_data = data[bytes_to_copy:]  # Сохраняем оставшиеся данные\n                else:\n                    i = 0\n                    # print(n)\n                    while n < output_len and i < chunk_size:\n                        output_items[0][n] = data[i] \n                        output_items[1][n] = data[i + 1]\n                        n += 1\n                        i += 2\n                    # output_items[1][n-1] = 300\n                    self.remaining_data = bytearray(USB_PACKET_SIZE - i + 1)\n                    self.remaining_data[1:] = data[i:]  # Сохраняем оставшиеся данные\n                    self.remaining_data[0] = (0 if (USB_PACKET_SIZE - i) == 0 else 1)  # Флаг запроса чтения\n                    # print(n)\n                    # print(self.remaining_data)\n\n            return len(output_items[0])  # Возвращаем количество обработанных элементов\n\n\n\n\n                # Случай, когда mode >= 4 (dac_mode) - упор на ЦАП, АЦП отключен\n        # Случай, когда mode >= 4 (dac_mode) - упор на ЦАП, АЦП отключен\n        else:\n            data = bytearray(USB_PACKET_SIZE )  # Создание массива байтов для чтения данных\n            n = 0\n            remaining_len = 0\n            input_len = min(len(input_items[0]), len(input_items[1]))  # Используем минимальную длину для избежания выхода за границы\n\n            # Если есть remaining_data, объединяем его с текущими данными\n            if self.remaining_data:\n                remaining_len = len(self.remaining_data)\n                # Увеличиваем размер буфера, добавляя длину remaining_data\n                data = self.remaining_data + data[:USB_PACKET_SIZE  - remaining_len]  # Ограничиваем data по размеру\n                self.remaining_data = bytearray()  # Очищаем буфер после объединения\n\n            while n < input_len:\n                i = remaining_len  # Сбрасываем индекс для data\n\n                while i < (USB_PACKET_SIZE ) and n < input_len:  # Проверяем и n\n                    value1 = int((input_items[0][n] + 1) * 4095 / 2) & 0xFFFF  # Приведение к целому числу и ограничение до 16 бит\n                    data[i] = value1 & 0xFF  # Младший байт\n                    data[i + 1] = (value1 >> 8) & 0xFF  # Старший байт\n                    i += 2\n                    value2 = int((input_items[1][n] + 1) * 4095 / 2) & 0xFFFF  # Приведение к целому числу и ограничение до 16 бит\n                    data[i] = value2 & 0xFF  # Младший байт\n                    data[i + 1] = (value2 >> 8) & 0xFF  # Старший байт\n                    i += 2\n                    n += 1\n\n                # Отправляем собранные данные в порт\n                self.port.write(data)  # Отправляем только заполненную часть\n                remaining_len = 0\n                data = bytearray(USB_PACKET_SIZE )\n\n            # Обработка оставшихся данных\n            if n < input_len:\n                remaining_data = bytearray()\n\n                while n < input_len and i < USB_PACKET_SIZE :\n                    value1 = int((input_items[0][n] + 1) * 4095 / 2) & 0xFFFF\n                    remaining_data.append(value1 & 0xFF)\n                    remaining_data.append((value1 >> 8) & 0xFF)\n                    i += 2\n                    value2 = int((input_items[1][n] + 1) * 4095 / 2) & 0xFFFF\n                    remaining_data.append(value2 & 0xFF)\n                    remaining_data.append((value2 >> 8) & 0xFF)\n                    i += 2\n                    n += 1\n\n                # Сохраняем остаточные данные для следующего вызова\n                self.remaining_data = remaining_data\n\n            return len(input_items[0])\n\n"
    comment: |-
      mode = 0,    // 1ый канал АЦП, 1ый канал ЦАП 
      mode  = 1,    // 1ый канал АЦП, 2 канала ЦАП    
      mode  = 2,    // 2 канала АЦП, 1ый канала ЦАП  
      mode = 3,    // 2 канала АЦП, 2 канала ЦАП
      mode >= 4  // dac_mode
    mode: '20'
    portNumber: '7'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport serial\nimport serial.tools.list_ports\nimport time\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nMAX_DAC_NUM = 500   # Максимальное количество чисел, которое может быть записано в const_signal\nMAX_DAC_VAL = 10.0  # Максимальное значение на выходе ЦАП\nCHUNK_SIZE = 10     # Максимальное количество чисел в одной команде\nUSB_PACKET_SIZE = 32 # байт\n# USB_PACKET_SIZE = 256 # байт              ДЛЯ dac mode\n\n\nclass ADIBlock(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"\n    Read data from serial port and forward it to output. \n    portNumber is number, you can see in the name of your \n    serial port in device manager, like COM16 or COM7 \n    \"\"\"\n\n    \n    def __init__(self, portNumber=7, mode = 3): \n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        self.portNumber = portNumber  # Сохраняем номер порта\n        # portName = 'COM' + str(portNumber)                  # Concatenate string and number\n        \n        gr.sync_block.__init__(\n            self,\n            name = 'Analog Digital Interface',   \n            in_sig = [np.float32, np.float32],                # Входы\n            out_sig = [np.float32, np.float32]  # Выходы\n        )\n\n        # Регистрация именованных входных и выходных портов\n        self.message_port_register_in(pmt.intern('set_const_signal'))\n        self.set_msg_handler(pmt.intern('set_const_signal'), self.handle_msg)\n        # self.message_port_register_out(pmt.intern('msg_out'))\n\n         # Инициализация переменных для COM порта\n        self.port = None\n        self.port_name = None\n        self.baudrate = 2000000  # Здесь захардкожен baudrate\n        self.mode = mode\n        self.remaining_data = bytearray(USB_PACKET_SIZE + 1)  # Буфер для оставшихся данных     0ой байт - флаг (0 - в массиве нет полезных данных, 1 - надо читать)\n        \n    def open_port(self):\n        \"\"\"Открывает COM порт, если он существует и не занят.\"\"\"\n        baudrate = 2000000\n        portName = 'COM' + str(self.portNumber)\n\n        # Получаем список доступных COM портов\n        available_ports = [port.device for port in serial.tools.list_ports.comports()]\n\n        if portName not in available_ports:\n            print(f\"Ошибка: Порт {portName} не найден.\")\n            return\n        \n        try:\n            # Пытаемся открыть порт\n            self.port = serial.Serial(portName, baudrate, timeout=3.0)\n            # Если порт уже был открыт, закрываем его и открываем заново\n            if self.port.is_open:\n                self.port.close()\n                self.port.open()\n            else:\n                self.port.open()\n            print(f\"Порт {portName} успешно открыт.\")\n        except serial.SerialException as e:\n            # Если не удалось открыть порт (например, он занят), выводим сообщение об ошибке\n            print(f\"Ошибка при открытии порта {portName}: {e}\")\n            self.port = None\n\n\n    def set_mode(self, mode_setting):\n        if mode_setting < 4:\n            command = \"mode \" + str(mode_setting)  \n        else:\n            command = \"dac_mode\"\n        try:\n            self.port.write(command.encode('ascii'))\n            print(f\"Отправлено: {command}\")\n            time.sleep(0.01)\n        except serial.SerialException as e:\n            print(f\"Ошибка при отправке данных: {e}\")\n\n\n    def handle_msg(self, msg):\n        \"\"\"Обработка входных сообщений.\"\"\"\n        # Преобразование сообщения в список чисел с плавающей запятой\n        numbers = pmt.to_python(msg)        # Преобразование в строку\n        numbers = [float(x) for x in numbers.split()]\n        print(\"AAAAAAAAAAAAAAAAAAAAAA\")\n        # print(numbers[30])\n\n        # if not isinstance(numbers, list):\n        #     print(\"Ошибка: Ожидался список чисел.\")\n        #     return\n\n        if len(numbers) > MAX_DAC_NUM:\n            print(f\"Ошибка: Слишком много чисел. Максимум {MAX_DAC_NUM}.\")\n            return\n\n        if any(val > MAX_DAC_VAL for val in numbers):\n            print(f\"Ошибка: Значения не могут превышать {MAX_DAC_VAL}.\")\n            return\n\n        # Открытие порта, если еще не открыт\n        if self.port is None:\n            self.open_port()\n\n        if self.port is not None and self.port.is_open:\n            # Разделение данных на куски по 10 чисел и отправка\n            for i in range(0, len(numbers), CHUNK_SIZE):\n                chunk = numbers[i:i + CHUNK_SIZE]\n                command = \"set \" + \" \".join(map(str, chunk))\n                if i + CHUNK_SIZE >= len(numbers):\n                    command += \" !\"\n                \n                try:\n                    self.port.write(command.encode('ascii'))\n                    print(f\"Отправлено: {command}\")\n                    time.sleep(0.01)\n                except serial.SerialException as e:\n                    print(f\"Ошибка при отправке данных: {e}\")\n\n\n            \n    def work(self, input_items, output_items):\n\n        if self.port is None:\n            # Если порт не открыт, попытаться открыть его\n            self.open_port()\n            self.set_mode(self.mode)\n\n        # Случай обычной работы (Упор на АЦП)\n        if self.mode < 4:\n            n = 0\n            chunk_size = USB_PACKET_SIZE\n            output_len = len(output_items[0])\n            # print (output_len)\n            data = bytearray(chunk_size)  # Создание массива байтов для чтения данных\n            n_increment = (USB_PACKET_SIZE if self.mode < 3 else (USB_PACKET_SIZE // 2))\n\n                \n            while n < (output_len - n_increment):\n                chunk_size = USB_PACKET_SIZE\n            \n                # Объединяем остаточные данные из предыдущей итерации с новыми\n                if self.remaining_data[0] == 1:\n                    # data = bytearray(chunk_size)  # Создание массива байтов для чтения данных\n                    chunk_size = len(self.remaining_data) - 1\n                    data = bytearray(chunk_size)\n                    data = self.remaining_data[1:]       # Сохранить данные \n                    # print (data)\n                    # data[-1:] = b'\\x00'\n                    # print(len(self.remaining_data))\n                    # print(data)\n                    # print(\"YES\")\n                    # while True:\n                    #     pass\n                    self.remaining_data = bytearray(USB_PACKET_SIZE + 1)  # Очищаем буфер\n                else:\n                    data = bytearray(chunk_size)  # Создание массива байтов для чтения данных\n                    self.port.readinto(data)  # Считывание данных непосредственно в массив байтов\n\n                if self.mode < 2:  # mode can be 0 or 1, оба включают только 1 канал АЦП\n                    output_items[0][n:n + chunk_size] = data[:chunk_size]\n                    n += chunk_size\n                else:\n                    # TEST 8 bit\n                    output_items[0][n:n + chunk_size // 2] = data[0::2]\n                    output_items[1][n:n + chunk_size // 2] = data[1::2]\n                    # output_items[1][n] = b'\\x30'\n                    n += chunk_size // 2\n\n                    # TESST\n\n            # Обработка оставшегося места в output_items\n            if n < output_len:\n                self.port.readinto(data)  # Считываем данные в массив байтов\n                if self.mode < 2:  # mode can be 0 или 1, оба включают только 1 канал АЦП\n                    bytes_to_copy = min(chunk_size, output_len - n)\n                    output_items[0][n:n + bytes_to_copy] = data[:bytes_to_copy]\n                    n += bytes_to_copy\n                    self.remaining_data = data[bytes_to_copy:]  # Сохраняем оставшиеся данные\n                else:\n                    i = 0\n                    # print(n)\n                    while n < output_len and i < chunk_size:\n                        output_items[0][n] = data[i] \n                        output_items[1][n] = data[i + 1]\n                        n += 1\n                        i += 2\n                    # output_items[1][n-1] = 300\n                    self.remaining_data = bytearray(USB_PACKET_SIZE - i + 1)\n                    self.remaining_data[1:] = data[i:]  # Сохраняем оставшиеся данные\n                    self.remaining_data[0] = (0 if (USB_PACKET_SIZE - i) == 0 else 1)  # Флаг запроса чтения\n                    # print(n)\n                    # print(self.remaining_data)\n\n            return len(output_items[0])  # Возвращаем количество обработанных элементов\n\n\n\n\n                # Случай, когда mode >= 4 (dac_mode) - упор на ЦАП, АЦП отключен\n        # Случай, когда mode >= 4 (dac_mode) - упор на ЦАП, АЦП отключен\n        else:\n            data = bytearray(USB_PACKET_SIZE )  # Создание массива байтов для чтения данных\n            n = 0\n            remaining_len = 0\n            input_len = min(len(input_items[0]), len(input_items[1]))  # Используем минимальную длину для избежания выхода за границы\n\n            # Если есть remaining_data, объединяем его с текущими данными\n            if self.remaining_data:\n                remaining_len = len(self.remaining_data)\n                # Увеличиваем размер буфера, добавляя длину remaining_data\n                data = self.remaining_data + data[:USB_PACKET_SIZE  - remaining_len]  # Ограничиваем data по размеру\n                self.remaining_data = bytearray()  # Очищаем буфер после объединения\n\n            while n < input_len:\n                i = remaining_len  # Сбрасываем индекс для data\n\n                while i < (USB_PACKET_SIZE ) and n < input_len:  # Проверяем и n\n                    value1 = int((input_items[0][n] + 1) * 4095 / 2) & 0xFFFF  # Приведение к целому числу и ограничение до 16 бит\n                    data[i] = value1 & 0xFF  # Младший байт\n                    data[i + 1] = (value1 >> 8) & 0xFF  # Старший байт\n                    i += 2\n                    value2 = int((input_items[1][n] + 1) * 4095 / 2) & 0xFFFF  # Приведение к целому числу и ограничение до 16 бит\n                    data[i] = value2 & 0xFF  # Младший байт\n                    data[i + 1] = (value2 >> 8) & 0xFF  # Старший байт\n                    i += 2\n                    n += 1\n\n                # Отправляем собранные данные в порт\n                self.port.write(data)  # Отправляем только заполненную часть\n                remaining_len = 0\n                data = bytearray(USB_PACKET_SIZE )\n\n            # Обработка оставшихся данных\n            if n < input_len:\n                remaining_data = bytearray()\n\n                while n < input_len and i < USB_PACKET_SIZE :\n                    value1 = int((input_items[0][n] + 1) * 4095 / 2) & 0xFFFF\n                    remaining_data.append(value1 & 0xFF)\n                    remaining_data.append((value1 >> 8) & 0xFF)\n                    i += 2\n                    value2 = int((input_items[1][n] + 1) * 4095 / 2) & 0xFFFF\n                    remaining_data.append(value2 & 0xFF)\n                    remaining_data.append((value2 >> 8) & 0xFF)\n                    i += 2\n                    n += 1\n\n                # Сохраняем остаточные данные для следующего вызова\n                self.remaining_data = remaining_data\n\n            return len(input_items[0])\n\n"
    comment: |-
      mode = 0,    // 1ый канал АЦП, 1ый канал ЦАП 
      mode  = 1,    // 1ый канал АЦП, 2 канала ЦАП    
      mode  = 2,    // 2 канала АЦП, 1ый канала ЦАП  
      mode = 3,    // 2 канала АЦП, 2 канала ЦАП
      mode >= 4  // dac_mode
    mode: '3'
    portNumber: '10'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '100'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: r2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: r2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_2, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_0_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_float_0, '0', epy_block_0, '0']
- [blocks_complex_to_float_0, '1', epy_block_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_null_source_0, '0', epy_block_0_0, '0']
- [blocks_null_source_0_0, '0', epy_block_0_0, '1']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_complex_to_float_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', virtual_sink_1, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, '1', blocks_null_sink_0_0, '0']
- [epy_block_0_0, '0', blocks_add_const_vxx_0, '0']
- [epy_block_0_0, '1', blocks_add_const_vxx_0_0, '0']
- [virtual_source_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [virtual_source_2, '0', blocks_unpack_k_bits_bb_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
