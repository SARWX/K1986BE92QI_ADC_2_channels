options:
  parameters:
    author: Barry Duggan
    category: Custom
    generate_options: qt_gui
    id: qpsk_stage6
    output_language: python
    title: qpsk_stage6
  states: {}

blocks:
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport serial\nimport serial.tools.list_ports\nimport time\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nMAX_DAC_NUM = 500   # Максимальное количество чисел, которое может быть записано в const_signal\nMAX_DAC_VAL = 10.0  # Максимальное значение на выходе ЦАП\nCHUNK_SIZE = 10     # Максимальное количество чисел в одной команде\nUSB_PACKET_SIZE = 64 # байт\n# USB_PACKET_SIZE = 256 # байт              ДЛЯ dac mode\n\n\nclass ADIBlock(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"\n    Read data from serial port and forward it to output. \n    portNumber is number, you can see in the name of your \n    serial port in device manager, like COM16 or COM7 \n    \"\"\"\n\n    \n    def __init__(self, portNumber=7, mode = 3): \n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        self.portNumber = portNumber  # Сохраняем номер порта\n        # portName = 'COM' + str(portNumber)                  # Concatenate string and number\n        \n        gr.sync_block.__init__(\n            self,\n            name = 'Analog Digital Interface',   \n            in_sig = [np.float32, np.float32],                # Входы\n            out_sig = [np.float32, np.float32]  # Выходы\n        )\n        # Регистрация именованных входных и выходных портов\n        self.message_port_register_in(pmt.intern('set_const_signal'))\n        self.set_msg_handler(pmt.intern('set_const_signal'), self.handle_msg)\n        # self.message_port_register_out(pmt.intern('msg_out'))\n        self.set_min_output_buffer(2**13)        # 512 - минимальный размер\n        self.set_max_output_buffer(2**13)  # Установка максимального размера буфера\n        self.set_output_multiple(2**13)     # Установка шага данных\n\n         # Инициализация переменных для COM порта\n        self.port = None\n        self.port_name = None\n        self.baudrate = 2000000  # Здесь захардкожен baudrate\n        self.mode = mode\n        self.remaining_data = bytearray(USB_PACKET_SIZE + 1)  # Буфер для оставшихся данных     0ой байт - флаг (0 - в массиве нет полезных данных, 1 - надо читать)\n        \n    def open_port(self):\n        \"\"\"Открывает COM порт, если он существует и не занят.\"\"\"\n        baudrate = 2000000\n        portName = 'COM' + str(self.portNumber)\n\n        # Получаем список доступных COM портов\n        available_ports = [port.device for port in serial.tools.list_ports.comports()]\n\n        if portName not in available_ports:\n            print(f\"Ошибка: Порт {portName} не найден.\")\n            return\n        \n        try:\n            # Пытаемся открыть порт\n            self.port = serial.Serial(portName, baudrate, timeout=3.0)\n            # Если порт уже был открыт, закрываем его и открываем заново\n            if self.port.is_open:\n                self.port.close()\n                self.port.open()\n            else:\n                self.port.open()\n            print(f\"Порт {portName} успешно открыт.\")\n        except serial.SerialException as e:\n            # Если не удалось открыть порт (например, он занят), выводим сообщение об ошибке\n            print(f\"Ошибка при открытии порта {portName}: {e}\")\n            self.port = None\n\n\n    def set_mode(self, mode_setting):\n        if mode_setting < 4:\n            command = \"mode \" + str(mode_setting)  \n        else:\n            command = \"dac_mode\"\n        try:\n            self.port.write(command.encode('ascii'))\n            print(f\"Отправлено: {command}\")\n            time.sleep(0.01)\n        except serial.SerialException as e:\n            print(f\"Ошибка при отправке данных: {e}\")\n\n\n    def handle_msg(self, msg):\n        \"\"\"Обработка входных сообщений.\"\"\"\n        # Преобразование сообщения в список чисел с плавающей запятой\n        numbers = pmt.to_python(msg)        # Преобразование в строку\n        numbers = [float(x) for x in numbers.split()]\n        print(\"AAAAAAAAAAAAAAAAAAAAAA\")\n        # print(numbers[30])\n\n        # if not isinstance(numbers, list):\n        #     print(\"Ошибка: Ожидался список чисел.\")\n        #     return\n\n        if len(numbers) > MAX_DAC_NUM:\n            print(f\"Ошибка: Слишком много чисел. Максимум {MAX_DAC_NUM}.\")\n            return\n\n        if any(val > MAX_DAC_VAL for val in numbers):\n            print(f\"Ошибка: Значения не могут превышать {MAX_DAC_VAL}.\")\n            return\n\n        # Открытие порта, если еще не открыт\n        if self.port is None:\n            self.open_port()\n\n        if self.port is not None and self.port.is_open:\n            # Разделение данных на куски по 10 чисел и отправка\n            for i in range(0, len(numbers), CHUNK_SIZE):\n                chunk = numbers[i:i + CHUNK_SIZE]\n                command = \"set \" + \" \".join(map(str, chunk))\n                if i + CHUNK_SIZE >= len(numbers):\n                    command += \" !\"\n                \n                try:\n                    self.port.write(command.encode('ascii'))\n                    print(f\"Отправлено: {command}\")\n                    time.sleep(0.01)\n                except serial.SerialException as e:\n                    print(f\"Ошибка при отправке данных: {e}\")\n\n\n            \n    def work(self, input_items, output_items):\n\n        if self.port is None:\n            # Если порт не открыт, попытаться открыть его\n            self.open_port()\n            self.set_mode(self.mode)\n\n        # Случай обычной работы (Упор на АЦП)\n        if self.mode < 4:\n            n = 0\n            chunk_size = USB_PACKET_SIZE\n            output_len = len(output_items[0])\n            # print (output_len)\n            data = bytearray(chunk_size)  # Создание массива байтов для чтения данных\n            n_increment = (USB_PACKET_SIZE if self.mode < 3 else (USB_PACKET_SIZE // 2))\n\n                \n            while n < (output_len - n_increment):\n                chunk_size = USB_PACKET_SIZE\n            \n                # Объединяем остаточные данные из предыдущей итерации с новыми\n                if self.remaining_data[0] == 1:\n                    print(\"REMAINING DATA = \", len(self.remaining_data))\n                    # data = bytearray(chunk_size)  # Создание массива байтов для чтения данных\n                    chunk_size = len(self.remaining_data) - 1\n                    data = bytearray(chunk_size)\n                    data = self.remaining_data[1:]       # Сохранить данные \n                    # print (data)\n                    # data[-1:] = b'\\x00'\n                    # print(len(self.remaining_data))\n                    # print(data)\n                    # print(\"YES\")\n                    # while True:\n                    #     pass\n                    self.remaining_data = bytearray(USB_PACKET_SIZE + 1)  # Очищаем буфер\n                else:\n                    data = bytearray(chunk_size)  # Создание массива байтов для чтения данных\n                    self.port.readinto(data)  # Считывание данных непосредственно в массив байтов\n\n                if self.mode < 2:  # mode can be 0 or 1, оба включают только 1 канал АЦП\n                    output_items[0][n:n + chunk_size] = data[:chunk_size]\n                    n += chunk_size\n                else:\n                    # TEST 8 bit\n                    output_items[0][n:n + chunk_size // 2] = data[0::2]\n                    output_items[1][n:n + chunk_size // 2] = data[1::2]\n                    # output_items[1][n] = b'\\x30'\n                    n += chunk_size // 2\n\n                    # TESST\n\n            # Обработка оставшегося места в output_items\n            if n < output_len:\n                self.port.readinto(data)  # Считываем данные в массив байтов\n                if self.mode < 2:  # mode can be 0 или 1, оба включают только 1 канал АЦП\n                    bytes_to_copy = min(chunk_size, output_len - n)\n                    output_items[0][n:n + bytes_to_copy] = data[:bytes_to_copy]\n                    n += bytes_to_copy\n                    self.remaining_data = data[bytes_to_copy:]  # Сохраняем оставшиеся данные\n                else:\n                    i = 0\n                    # print(n)\n                    while n < output_len and i < chunk_size:\n                        output_items[0][n] = data[i] \n                        output_items[1][n] = data[i + 1]\n                        n += 1\n                        i += 2\n                    # output_items[1][n-1] = 300\n                    self.remaining_data = bytearray(USB_PACKET_SIZE - i + 1)\n                    self.remaining_data[1:] = data[i:]  # Сохраняем оставшиеся данные\n                    self.remaining_data[0] = (0 if (USB_PACKET_SIZE - i) == 0 else 1)  # Флаг запроса чтения\n                    # print(n)\n                    # print(self.remaining_data)\n\n            # # TEST\n            # output_items[0][0] = -1\n            # output_items[0][output_len - 1] = -3\n            \n\n            return len(output_items[0])  # Возвращаем количество обработанных элементов\n\n\n\n\n                # Случай, когда mode >= 4 (dac_mode) - упор на ЦАП, АЦП отключен\n        # Случай, когда mode >= 4 (dac_mode) - упор на ЦАП, АЦП отключен\n        else:\n            data = bytearray(USB_PACKET_SIZE )  # Создание массива байтов для чтения данных\n            n = 0\n            remaining_len = 0\n            input_len = min(len(input_items[0]), len(input_items[1]))  # Используем минимальную длину для избежания выхода за границы\n\n            # Если есть remaining_data, объединяем его с текущими данными\n            if self.remaining_data:\n                remaining_len = len(self.remaining_data)\n                # Увеличиваем размер буфера, добавляя длину remaining_data\n                data = self.remaining_data + data[:USB_PACKET_SIZE  - remaining_len]  # Ограничиваем data по размеру\n                self.remaining_data = bytearray()  # Очищаем буфер после объединения\n\n            while n < input_len:\n                i = remaining_len  # Сбрасываем индекс для data\n\n                while i < (USB_PACKET_SIZE ) and n < input_len:  # Проверяем и n\n                    value1 = int((input_items[0][n] + 1) * 4095 / 2) & 0xFFFF  # Приведение к целому числу и ограничение до 16 бит\n                    data[i] = value1 & 0xFF  # Младший байт\n                    data[i + 1] = (value1 >> 8) & 0xFF  # Старший байт\n                    i += 2\n                    value2 = int((input_items[1][n] + 1) * 4095 / 2) & 0xFFFF  # Приведение к целому числу и ограничение до 16 бит\n                    data[i] = value2 & 0xFF  # Младший байт\n                    data[i + 1] = (value2 >> 8) & 0xFF  # Старший байт\n                    i += 2\n                    n += 1\n\n                # Отправляем собранные данные в порт\n                self.port.write(data)  # Отправляем только заполненную часть\n                remaining_len = 0\n                data = bytearray(USB_PACKET_SIZE )\n\n            # Обработка оставшихся данных\n            if n < input_len:\n                remaining_data = bytearray()\n\n                while n < input_len and i < USB_PACKET_SIZE :\n                    value1 = int((input_items[0][n] + 1) * 4095 / 2) & 0xFFFF\n                    remaining_data.append(value1 & 0xFF)\n                    remaining_data.append((value1 >> 8) & 0xFF)\n                    i += 2\n                    value2 = int((input_items[1][n] + 1) * 4095 / 2) & 0xFFFF\n                    remaining_data.append(value2 & 0xFF)\n                    remaining_data.append((value2 >> 8) & 0xFF)\n                    i += 2\n                    n += 1\n\n                # Сохраняем остаточные данные для следующего вызова\n                self.remaining_data = remaining_data\n\n            return len(input_items[0])\n\n"
    comment: |-
      mode = 0 	- 1ый канал АЦП, 1ый канал ЦАП 
      mode  = 1	- 1ый канал АЦП, 2 канала ЦАП    
      mode  = 2	- 2 канала АЦП, 1ый канала ЦАП  
      mode = 3	- 2 канала АЦП, 2 канала ЦАП
      mode >= 4	- dac_mode
    mode: '3'
    portNumber: '10'
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import enum


      # class Scheduler(enum.Enum):
      #     first_channel = 0
      #     second_channel = 1
      #     deinit = 2

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Filter IQ QPSK',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32, np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              # WAIT = 10

              WAIT = 10 * 8 * 4
              packet_size_bytes = 10  # Размер пакета в байтах
              packet_size_bits = packet_size_bytes * 8  # 10 байт = 80 бит
              bit_size = 4  # Размер бита (для расчета шага при чтении)
              packet_size_mes = packet_size_bits * bit_size  # 10 байт = 80 бит
              # "Планировщик" распределяющий по каналам (кто раньше 0->1, тот первый канал) 
              # scheduler = Scheduler.first_channel
              scheduler = 0

              # 1 - Заполнить выходной массив нулями
              output_items[0].fill(0)
              output_items[1].fill(0)
              
              i = 0
              j = 0

              exact_num_of_mes_per_bit = 4.33
              count_mes_per_pack = 0
              prev_start = 0

              output_len = len(output_items[0])
              input_len = len(input_items[0])

              # print(input_len, output_len)
              test_mark = 0
              

              chan_0_start_condition = False
              chan_0_start_index = 0
              chan_1_start_condition = False
              chan_1_start_index = 0
              chan_num_0 = 0
              chan_num_1 = 1

              start_condition_found = False  # Флаг, найдено ли start_condition
              read_started = False  # Флаг, началось ли чтение
              bits_read = 0  # Счетчик прочитанных битов

              # Не надо читать буфер, если в него не может поместиться как миниум 1 полноценный пакет
              # Размер буфера почему-то постоянно меняется 
              if (input_len < WAIT + packet_size_mes):
                  return(output_len)

              while i < (input_len - 7):
                  if not start_condition_found:
                      # 1 - Либо одновременно, либо с шагом в 1 оба канала должны перейти в 1 
                      # 1 - Проверяем условие: оба канала последовательно перешли на 1
                      if input_items[0][i] > 0.4:
                          if chan_0_start_condition == False:
                              chan_0_start_index = (i + 2 + 4)
                              chan_num_0 = scheduler            # каким каналом назначен первый
                              scheduler += 1
                          chan_0_start_condition = True
                      if input_items[1][i] > 0.4:
                          if chan_1_start_condition == False:
                              chan_1_start_index = (i + 2 + 4)
                              chan_num_1 = scheduler            # каким каналом назначен второй
                              scheduler += 1
                          chan_1_start_condition = True

                      if (chan_0_start_condition and chan_1_start_condition):
                          if (abs(chan_0_start_index - chan_1_start_index) < 4):
                              start_condition_found = True
                              # print(i - test_mark)
                              read_started = True
                              bits_read = 0  # Сбрасываем счетчик прочитанных битов
                          else:
                              chan_0_start_condition = False
                              chan_1_start_condition = False
                              # scheduler = Scheduler.first_channel
                              scheduler = 0
                          # # Посчитаем точно сколько измерений приходится на 1 бит
                          # if prev_start != 0:
                          #     count_mes_per_pack = i - prev_start
                          #     exact_num_of_mes_per_bit = count_mes_per_pack / packet_size_bits
                          #     print(exact_num_of_mes_per_bit)
                          # prev_start = i

                      # if input_items[0][i] > 0.5 and input_items[1][i] > 0.5:
                      #     start_condition_found = True
                      #     read_started = True
                      #     bits_read = 0  # Сбрасываем счетчик прочитанных битов
                  else:
                      if read_started and (bits_read < packet_size_bits):
                          # 2 - Читаем биты с текущего индекса с шагом exact_num_of_mes_per_bit
                          if (i - chan_0_start_index) >= 0 and (i - chan_0_start_index) % exact_num_of_mes_per_bit < 1.0:
                              output_items[chan_num_0][j // 2] = (1 if input_items[0][i] > 0.5 else 0)
                              j += 1
                              bits_read += 1
                          if (i - chan_1_start_index) >= 0 and (i - chan_1_start_index) % exact_num_of_mes_per_bit < 1.0:
                              output_items[chan_num_1][j // 2] = (1 if input_items[1][i] > 0.5 else 0)
                              j += 1
                              bits_read += 1
                      else:
                          # Чтение завершено, сбрасываем флаг и ищем новое start_condition
                          start_condition_found = False
                          read_started = False
                          chan_0_start_condition = False
                          chan_1_start_condition = False
                          bits_read = 0
                          scheduler = 0
                          j += packet_size_bits * 4   # (packet_size_bits * 2)    - нули и полезная нагрузка
                                                                                  # (+ 1) - 0x3               - начало фрейма
                                                                                  # (- packet_size_bits)      - мы уже передали 1 пакет битов, надо их учесть
                          stop_trig = 0
                          # i += (WAIT / 2)
                          while (i < input_len and stop_trig < (WAIT / 2)):
                              if ((input_items[0][i] < 0.4) and (input_items[0][i] < 0.4)):
                                  stop_trig += 1
                              else:
                                  # print("STOP: ", stop_trig)
                                  stop_trig = 0
                              i += 1
                          # print("END: ", stop_trig)
                          test_mark = i

                  i += 1  # Шаг в любом случае

              # output_items[0][0] = 2
              # output_items[0][output_len - 1] = 3
              # print(output_len)
              # print(input_len)

              return output_len
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      # import enum
      import time


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, modulation_type = 0, mode = 0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Extract information IQ',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32]
              )
              # self.set_min_output_buffer(2**13)        # 512 - минимальный размер
              # # self.set_max_output_buffer(2**9)  # Установка максимального размера буфера
              # self.set_output_multiple(2**13)     # Установка шага данных
              # if an attribute with the same name as a parameter is found,
              self.num_good_bytes = 0
              self.num_bad_bytes = 0
              self.modulation_type = modulation_type
              self.mode = mode            # Stream / Messenger
              self.message = ""
              self.test_complite = 0 
              self.test_start_time = 0
              self.test_end_time = 0

          def work(self, input_items, output_items):
              i = 0
              j = 0

              GOOD_BYTE = "<"

              res_msec = 0
              # num_good_bytes = 0
              output_len = len(output_items[0])
              input_len = len(input_items[0])
              packet_size_bytes = 10  # Размер пакета в байтах
              packet_size_bits = packet_size_bytes * 8  # 10 байт = 80 бит


              while i < output_len - packet_size_bytes * 8:
                  # 1 - прочитать пакет:
                  packet_str = ""
                  readed_bytes = 0

                  # start = time.time()
                  while (readed_bytes < packet_size_bytes) and (i < (output_len - 8)):
                      byte = 0
                      # QPSK
                      if self.modulation_type == 0:
                          for n in range(0, 4):
                              byte <<= 2
                              byte += (1 if input_items[1][i] > 0.5  else 0)
                              byte += (1 if input_items[0][i] > 0.5  else 0) * 2
                              i += 1
                      # QAM16
                      if self.modulation_type == 1:
                          for n in range(2):
                              byte <<= 4
                              
                              # Работа с input_items[1][i]
                              byte += (0 if input_items[1][i] < 0.2 else 
                                      1 if input_items[1][i] < 0.4 else 
                                      2 if input_items[1][i] < 0.8 else 3)

                              # Работа с input_items[0][i]
                              byte += ((0 if input_items[0][i] < 0.2 else 
                                      1 if input_items[0][i] < 0.4 else 
                                      2 if input_items[0][i] < 0.8 else 3) * 4)
                              
                              # Увеличиваем индекс
                              i += 1

                      # if byte != 0:
                          # print(byte)
                      output_items[0][j] = byte
                      j += 1
                      byte = chr(byte)

                      # Messenger
                      if self.mode == 1:
                          # Конец строки?
                          # if byte == '\n' or byte == '\r' or byte == ';':
                              # print(self.message)
                              # self.message = ""
                          # Символ может быть интерпретирован?
                          # elif ord(byte) > 0:
                              # print(byte)
                              # self.message += byte

                          if byte.isprintable():
                              # print(byte, end = '')
                              try:
                                  print(byte, end='')
                              except UnicodeEncodeError:
                                  pass  # Игнорируем символ, если его нельзя вывести

                      # Stream

                      # Test
                      elif self.mode == 2:
                          # if 31 < byte < 127:

                          # ЗАМЕР СКОРОСТИ И ОШИБКИ
                          if ord(byte) > 0:
                              if byte == GOOD_BYTE:
                                  self.num_good_bytes += 1
                              else:
                                  self.num_bad_bytes += 1
                              if self.test_start_time == 0:
                                  self.test_start_time = time.time()
              
                  
                      #     readed_bytes += 1
                      # if j == 10:
                      #     finish = time.time()
                      #     res = finish - start
                      #     res_msec = res * 1000
                      # 2 - пропустить нули
                      # print(packet_str, end = '')
                      # print(packet_str)
                      # i += (packet_size_bits * 4)

                  # print('Время работы в миллисекундах: ', res_msec)
                  # print('хороших байт: ', num_good_bytes)
                  if self.num_good_bytes > 100000 and self.test_complite == 0:
                      self.test_end_time = time.time()
                      print("\n")
                      print("Bitrate:\t\t\t\t", int(self.num_good_bytes / (self.test_end_time - self.test_start_time)), " Bytes/s")
                      print("BER (bit error ratio):\t", round((self.num_bad_bytes / (self.num_good_bytes + self.num_bad_bytes)) * 100, 2) , " %")
                      self.test_complite = 1

              return output_len
    comment: |-
      modulation_type = 0	- QPSK
      modulation_type = 1	- QAM16

      mode = 0 	- stream
      mode = 1 	- messenger
      mode = 2 	- test
    mode: '1'
    modulation_type: '1'
  states: {}
- name: epy_block_1_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import enum


      # class Scheduler(enum.Enum):
      #     first_channel = 0
      #     second_channel = 1
      #     deinit = 2

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, modulation_type = 0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Filter IQ',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32, np.float32]
              )
              # self.set_min_output_buffer(2**13)        # 512 - минимальный размер
              # # self.set_max_output_buffer(2**9)  # Установка максимального размера буфера
              # self.set_output_multiple(2**13)     # Установка шага данных

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.modulation_type = modulation_type

          def work(self, input_items, output_items):
              # WAIT = 10

              cnt_start_cond = 0

              WAIT = 10 * 8 * 4
              packet_size_bytes = 10  # Размер пакета в байтах
              packet_size_bits = packet_size_bytes * 8  # 10 байт = 80 бит
              bit_size = 4  # Размер бита (для расчета шага при чтении)
              packet_size_mes = packet_size_bits * bit_size  # 10 байт = 80 бит
              # "Планировщик" распределяющий по каналам (кто раньше 0->1, тот первый канал) 
              # scheduler = Scheduler.first_channel
              scheduler = 0

              # 1 - Заполнить выходной массив нулями
              output_items[0].fill(0)
              output_items[1].fill(0)
              
              i = 0
              j = 0

              exact_num_of_mes_per_bit = 4.33
              count_mes_per_pack = 0
              prev_start = 0

              output_len = len(output_items[0])
              # print("output len = ", output_len)
              input_len = len(input_items[0])
              # print("input len = ", input_len)


              # print(input_len, output_len)
              test_mark = 0
              

              chan_0_start_condition = False
              chan_0_start_index = 0
              chan_1_start_condition = False
              chan_1_start_index = 0
              chan_num_0 = 0
              chan_num_1 = 1

              start_condition_found = False  # Флаг, найдено ли start_condition
              read_started = False  # Флаг, началось ли чтение
              bits_read = 0  # Счетчик прочитанных битов

              # Не надо читать буфер, если в него не может поместиться как миниум 1 полноценный пакет
              # Размер буфера почему-то постоянно меняется 
              # if (input_len < WAIT + packet_size_mes):
              #     return(output_len)

              # Для нормализации будем делить заносимые значения на амплитуду
              amplitude = max(input_items[0])
              # Амплитуда не должна быть меньше 0.8
              if amplitude < 0.8:
                  amplitude = 1.0
              threshold = amplitude * 0.4
              
              # print(input_len)
              while i < (input_len - 7):
                  if not start_condition_found:
                      # 1 - Либо одновременно, либо с шагом в 1 оба канала должны перейти в 1 
                      # 1 - Проверяем условие: оба канала последовательно перешли на 1
                      if input_items[0][i] > threshold:
                          if chan_0_start_condition == False:
                              chan_0_start_index = (i + 2 + 4)
                              chan_num_0 = scheduler            # каким каналом назначен первый
                              scheduler += 1
                          chan_0_start_condition = True
                      if input_items[1][i] > threshold:
                          if chan_1_start_condition == False:
                              chan_1_start_index = (i + 2 + 4)
                              chan_num_1 = scheduler            # каким каналом назначен второй
                              scheduler += 1
                          chan_1_start_condition = True

                      if (chan_0_start_condition and chan_1_start_condition):
                          if (abs(chan_0_start_index - chan_1_start_index) < 8):
                              start_condition_found = True
                              cnt_start_cond += 1
                              read_started = True
                              bits_read = 0  # Сбрасываем счетчик прочитанных битов
                          else:
                              chan_0_start_condition = False
                              chan_1_start_condition = False
                              scheduler = 0
                  else:
                      if read_started and (bits_read < packet_size_bits):
                          # 2 - Читаем биты с текущего индекса с шагом exact_num_of_mes_per_bit
                          if (i - chan_0_start_index) >= 0 and (i - chan_0_start_index) % exact_num_of_mes_per_bit < 1.0:
                              # output_items[chan_num_0][j // 2] = (1 if input_items[0][i] > 0.5 else 0)
                              output_items[chan_num_0][j // 2] = (input_items[0][i] / amplitude)
                              j += 1
                              bits_read += 1
                          if (i - chan_1_start_index) >= 0 and (i - chan_1_start_index) % exact_num_of_mes_per_bit < 1.0:
                              # output_items[chan_num_1][j // 2] = (1 if input_items[1][i] > 0.5 else 0)
                              output_items[chan_num_1][j // 2] = (input_items[1][i] / amplitude)
                              j += 1
                              bits_read += 1
                              # print(bits_read, i)
                      else:
                          # Чтение завершено, сбрасываем флаг и ищем новое start_condition
                          # print("ENDED! i = ", i)
                          start_condition_found = False
                          read_started = False
                          chan_0_start_condition = False
                          chan_1_start_condition = False
                          bits_read = 0
                          scheduler = 0
                          j += int(packet_size_bits * 4 / (self.modulation_type + 1))   # (packet_size_bits * 2)    - нули и полезная нагрузка
                                                                                  # (+ 1) - 0x3               - начало фрейма
                                                                                  # (- packet_size_bits)      - мы уже передали 1 пакет битов, надо их учесть
                          stop_trig = 0
                          # while (i < input_len and (stop_trig < ((WAIT / 2) / (self.modulation_type * 3 + 1)))):
                          while (i < input_len and (stop_trig < 4)):
                              if ((input_items[0][i] < threshold) and (input_items[0][i] < threshold)):
                                  stop_trig += 1
                                  # print("STOP_TRIG = ", stop_trig) 
                              else:
                                  # print("DELETED STOP_TRIG WAS EQUAL = ", stop_trig) 
                                  stop_trig = 0
                              i += 1
                          test_mark = i
                          # print(i)
                  i += 1  # Шаг в любом случае

              # print(cnt_start_cond)
              return output_len
    comment: |-
      modulation_type = 0	- QPSK
      modulation_type = 1	- QAM16
    modulation_type: '1'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,2,2
    size: '10000'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    xmax: '1.5'
    xmin: '-0.5'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,4
    size: 1024*4
    srate: '100000'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '256'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_2_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 1,2,2,2
    nconnections: '2'
    size: 1024*4
    srate: '100000'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_2_1_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    nconnections: '2'
    size: 1024*4
    srate: '100000'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymin: '0'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_null_source_0, '0', epy_block_0_0, '0']
- [blocks_null_source_0_0, '0', epy_block_0_0, '1']
- [epy_block_0_0, '0', epy_block_1_0_0_1, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0_2_1_0, '0']
- [epy_block_0_0, '1', epy_block_1_0_0_1, '1']
- [epy_block_0_0, '1', qtgui_time_sink_x_0_2_1_0, '1']
- [epy_block_1_0_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [epy_block_1_0_0_1, '0', blocks_float_to_complex_0, '0']
- [epy_block_1_0_0_1, '0', epy_block_1_0_0_0, '0']
- [epy_block_1_0_0_1, '0', qtgui_time_sink_x_0_2_1, '0']
- [epy_block_1_0_0_1, '1', blocks_float_to_complex_0, '1']
- [epy_block_1_0_0_1, '1', epy_block_1_0_0_0, '1']
- [epy_block_1_0_0_1, '1', qtgui_time_sink_x_0_2_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
